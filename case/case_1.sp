pure_res_net dimension=100 origin
R_1_2 1 2 1.092118e+00
R_2_3 2 3 2.808813e+00
R_3_4 3 4 8.472370e+00
R_4_5 4 5 1.275944e-01
R_5_6 5 6 3.705603e+00
R_6_7 6 7 2.469839e+00
R_7_8 7 8 2.488003e+00
R_8_9 8 9 3.184960e+00
R_9_10 9 10 4.599781e+00
R_10_11 10 11 3.782445e-01
R_11_12 11 12 6.806309e+00
R_12_13 12 13 4.762796e+00
R_13_14 13 14 2.135912e-01
R_14_15 14 15 4.724727e+00
R_15_16 15 16 8.914403e+00
R_16_17 16 17 5.111897e+00
R_17_18 17 18 2.151658e+00
R_18_19 18 19 5.448077e+00
R_19_20 19 20 8.993579e+00
R_20_21 20 21 5.580014e-01
R_21_22 21 22 4.487321e-01
R_22_23 22 23 4.637984e+00
R_23_24 23 24 1.333252e+00
R_24_25 24 25 1.700694e+00
R_25_26 25 26 2.702313e+00
R_26_27 26 27 1.074890e-01
R_27_28 27 28 5.874527e+00
R_28_29 28 29 7.865135e-01
R_29_30 29 30 5.125415e+00
R_30_31 30 31 5.253152e+00
R_31_32 31 32 3.351208e+00
R_32_33 32 33 7.820612e+00
R_33_34 33 34 9.943064e+00
R_34_35 34 35 7.114195e+00
R_35_36 35 36 2.549946e-01
R_36_37 36 37 2.919770e+00
R_37_38 37 38 6.763543e+00
R_38_39 38 39 5.077790e+00
R_39_40 39 40 3.925115e+00
R_40_41 40 41 2.403168e+00
R_41_42 41 42 8.980922e+00
R_42_43 42 43 5.432464e+00
R_43_44 43 44 1.134924e+00
R_44_45 44 45 1.679015e+00
R_45_46 45 46 2.293035e+00
R_46_47 46 47 3.506463e+00
R_47_48 47 48 7.597558e+00
R_48_49 48 49 5.438494e+00
R_49_50 49 50 9.441919e+00
R_50_51 50 51 3.290031e+00
R_51_52 51 52 8.741431e+00
R_52_53 52 53 4.701431e+00
R_53_54 53 54 9.303549e+00
R_54_55 54 55 8.637423e+00
R_55_56 55 56 9.656852e+00
R_56_57 56 57 4.211150e+00
R_57_58 57 58 3.089783e+00
R_58_59 58 59 6.953966e+00
R_59_60 59 60 1.025714e+00
R_60_61 60 61 8.433569e+00
R_61_62 61 62 6.473739e+00
R_62_63 62 63 1.905025e+00
R_63_64 63 64 6.851528e+00
R_64_65 64 65 2.990261e+00
R_65_66 65 66 7.058709e-01
R_66_67 66 67 3.286365e+00
R_67_68 67 68 6.985880e-01
R_68_69 68 69 9.158799e+00
R_69_70 69 70 3.060460e+00
R_70_71 70 71 6.935237e+00
R_71_72 71 72 2.529617e+00
R_72_73 72 73 9.207251e+00
R_73_74 73 74 4.249683e+00
R_74_75 74 75 2.715386e+00
R_75_76 75 76 4.781708e+00
R_76_77 76 77 3.638428e+00
R_77_78 77 78 2.082350e+00
R_78_79 78 79 4.196715e+00
R_79_80 79 80 3.977339e+00
R_80_81 80 81 6.883202e+00
R_81_82 81 82 8.168896e-02
R_82_83 82 83 1.318776e+00
R_83_84 83 84 6.520177e-01
R_84_85 84 85 3.125012e+00
R_85_86 85 86 7.974611e+00
R_86_87 86 87 8.463704e-01
R_87_88 87 88 5.193514e+00
R_88_89 88 89 2.620289e+00
R_89_90 89 90 6.888244e+00
R_90_91 90 91 4.683189e-01
R_91_92 91 92 8.209464e+00
R_92_93 92 93 2.002855e+00
R_93_94 93 94 4.803957e+00
R_94_95 94 95 5.103638e+00
R_95_96 95 96 4.769568e+00
R_96_97 96 97 4.388324e+00
R_97_98 97 98 2.043750e+00
R_98_99 98 99 9.732869e+00
R_99_100 99 100 1.732915e+00
R_101_102 101 102 9.556260e+00
R_102_103 102 103 3.496511e+00
R_103_104 103 104 9.536606e+00
R_104_105 104 105 2.583737e+00
R_105_106 105 106 4.730979e+00
R_106_107 106 107 1.034101e-01
R_107_108 107 108 8.636171e-01
R_108_109 108 109 9.362555e+00
R_109_110 109 110 7.400010e+00
R_110_111 110 111 7.186861e+00
R_111_112 111 112 7.557851e+00
R_112_113 112 113 6.327863e+00
R_113_114 113 114 2.026796e+00
R_114_115 114 115 9.108590e+00
R_115_116 115 116 2.583393e-01
R_116_117 116 117 2.818767e+00
R_117_118 117 118 9.077045e+00
R_118_119 118 119 1.589066e+00
R_119_120 119 120 2.107229e+00
R_120_121 120 121 9.899729e+00
R_121_122 121 122 5.858562e+00
R_122_123 122 123 1.231300e-01
R_123_124 123 124 3.520418e+00
R_124_125 124 125 7.538252e+00
R_125_126 125 126 6.271140e+00
R_126_127 126 127 2.514618e+00
R_127_128 127 128 2.460958e+00
R_128_129 128 129 5.592585e+00
R_129_130 129 130 3.848574e+00
R_130_131 130 131 5.810738e-01
R_131_132 131 132 4.241285e+00
R_132_133 132 133 6.811785e-01
R_133_134 133 134 6.650639e+00
R_134_135 134 135 3.243907e+00
R_135_136 135 136 1.576107e-01
R_136_137 136 137 1.886129e-01
R_137_138 137 138 2.660148e+00
R_138_139 138 139 3.804220e+00
R_139_140 139 140 4.618705e+00
R_140_141 140 141 1.028640e+00
R_141_142 141 142 9.066462e+00
R_142_143 142 143 2.680167e+00
R_143_144 143 144 3.546959e+00
R_144_145 144 145 5.039486e+00
R_145_146 145 146 1.724280e+00
R_146_147 146 147 7.410025e+00
R_147_148 147 148 3.722937e+00
R_148_149 148 149 4.996536e+00
R_149_150 149 150 9.878434e+00
R_150_151 150 151 1.702568e+00
R_151_152 151 152 1.105510e+00
R_152_153 152 153 7.970561e+00
R_153_154 153 154 3.836579e+00
R_154_155 154 155 1.011715e+00
R_155_156 155 156 7.645846e+00
R_156_157 156 157 6.577807e+00
R_157_158 157 158 6.042635e+00
R_158_159 158 159 8.747099e+00
R_159_160 159 160 2.137896e+00
R_160_161 160 161 6.038786e+00
R_161_162 161 162 1.550469e-01
R_162_163 162 163 1.228498e+00
R_163_164 163 164 2.437093e+00
R_164_165 164 165 7.940490e+00
R_165_166 165 166 1.317397e+00
R_166_167 166 167 4.870417e+00
R_167_168 167 168 2.108785e+00
R_168_169 168 169 5.825738e+00
R_169_170 169 170 6.685713e+00
R_170_171 170 171 9.615039e+00
R_171_172 171 172 6.222935e+00
R_172_173 172 173 6.064317e+00
R_173_174 173 174 9.653809e+00
R_174_175 174 175 2.840882e+00
R_175_176 175 176 1.624194e+00
R_176_177 176 177 7.846308e+00
R_177_178 177 178 1.819963e+00
R_178_179 178 179 9.656410e+00
R_179_180 179 180 2.265764e+00
R_180_181 180 181 9.428188e+00
R_181_182 181 182 3.257570e+00
R_182_183 182 183 5.927355e+00
R_183_184 183 184 6.008934e+00
R_184_185 184 185 2.860076e+00
R_185_186 185 186 5.812215e+00
R_186_187 186 187 2.894379e+00
R_187_188 187 188 6.758487e+00
R_188_189 188 189 2.589600e+00
R_189_190 189 190 5.047995e+00
R_190_191 190 191 2.299219e+00
R_191_192 191 192 4.928851e+00
R_192_193 192 193 4.714091e+00
R_193_194 193 194 3.017721e+00
R_194_195 194 195 3.528712e-01
R_195_196 195 196 7.741747e+00
R_196_197 196 197 9.843838e+00
R_197_198 197 198 6.289635e+00
R_198_199 198 199 7.222868e+00
R_199_200 199 200 7.230088e+00
R_201_202 201 202 1.399189e+00
R_202_203 202 203 9.876797e+00
R_203_204 203 204 5.355553e+00
R_204_205 204 205 7.805687e-01
R_205_206 205 206 6.803033e+00
R_206_207 206 207 2.521920e+00
R_207_208 207 208 2.498951e+00
R_208_209 208 209 8.756872e+00
R_209_210 209 210 4.411839e+00
R_210_211 210 211 6.549262e+00
R_211_212 211 212 5.026060e+00
R_212_213 212 213 4.314445e+00
R_213_214 213 214 6.589740e+00
R_214_215 214 215 5.009756e+00
R_215_216 215 216 3.953325e+00
R_216_217 216 217 3.499457e+00
R_217_218 217 218 6.273327e+00
R_218_219 218 219 1.124766e+00
R_219_220 219 220 1.379112e+00
R_220_221 220 221 9.922815e+00
R_221_222 221 222 6.467646e+00
R_222_223 222 223 9.871732e+00
R_223_224 223 224 7.991138e+00
R_224_225 224 225 7.665678e+00
R_225_226 225 226 7.841585e+00
R_226_227 226 227 3.491092e+00
R_227_228 227 228 5.964737e+00
R_228_229 228 229 7.181699e+00
R_229_230 229 230 5.962590e+00
R_230_231 230 231 6.862361e+00
R_231_232 231 232 3.470667e+00
R_232_233 232 233 5.039255e+00
R_233_234 233 234 5.109445e-01
R_234_235 234 235 4.471054e+00
R_235_236 235 236 8.209941e+00
R_236_237 236 237 3.636874e+00
R_237_238 237 238 6.098545e+00
R_238_239 238 239 9.008517e+00
R_239_240 239 240 5.217962e+00
R_240_241 240 241 5.234856e+00
R_241_242 241 242 3.681540e-01
R_242_243 242 243 7.854583e+00
R_243_244 243 244 1.086442e+00
R_244_245 244 245 4.681440e+00
R_245_246 245 246 4.268154e+00
R_246_247 246 247 8.682977e+00
R_247_248 247 248 2.605606e+00
R_248_249 248 249 3.988296e+00
R_249_250 249 250 8.579448e+00
R_250_251 250 251 8.881484e+00
R_251_252 251 252 8.974228e+00
R_252_253 252 253 3.666743e+00
R_253_254 253 254 4.184782e+00
R_254_255 254 255 4.687310e+00
R_255_256 255 256 1.093342e+00
R_256_257 256 257 6.296661e+00
R_257_258 257 258 4.122195e+00
R_258_259 258 259 7.754690e+00
R_259_260 259 260 2.075210e+00
R_260_261 260 261 8.107222e+00
R_261_262 261 262 3.067318e+00
R_262_263 262 263 9.692673e+00
R_263_264 263 264 2.948577e+00
R_264_265 264 265 7.367344e+00
R_265_266 265 266 2.988777e+00
R_266_267 266 267 9.906456e+00
R_267_268 267 268 4.875555e+00
R_268_269 268 269 5.854354e+00
R_269_270 269 270 5.040422e+00
R_270_271 270 271 9.766688e+00
R_271_272 271 272 3.787295e+00
R_272_273 272 273 4.346165e+00
R_273_274 273 274 1.313933e+00
R_274_275 274 275 5.068470e+00
R_275_276 275 276 3.386776e+00
R_276_277 276 277 7.808189e+00
R_277_278 277 278 4.114328e-01
R_278_279 278 279 3.900763e+00
R_279_280 279 280 1.125895e+00
R_280_281 280 281 5.236872e+00
R_281_282 281 282 3.613387e+00
R_282_283 282 283 5.992833e+00
R_283_284 283 284 2.109521e+00
R_284_285 284 285 9.904041e-01
R_285_286 285 286 7.423779e+00
R_286_287 286 287 3.202182e+00
R_287_288 287 288 3.137607e+00
R_288_289 288 289 4.018671e+00
R_289_290 289 290 2.548408e+00
R_290_291 290 291 3.649952e-01
R_291_292 291 292 5.201845e+00
R_292_293 292 293 3.378873e-01
R_293_294 293 294 7.834828e+00
R_294_295 294 295 5.288083e+00
R_295_296 295 296 5.526963e+00
R_296_297 296 297 3.062672e-01
R_297_298 297 298 2.231796e+00
R_298_299 298 299 6.936091e+00
R_299_300 299 300 9.150048e+00
R_301_302 301 302 3.533190e-01
R_302_303 302 303 2.222601e+00
R_303_304 303 304 6.418217e+00
R_304_305 304 305 8.787213e+00
R_305_306 305 306 4.272649e+00
R_306_307 306 307 2.226267e+00
R_307_308 307 308 7.716250e+00
R_308_309 308 309 3.861359e+00
R_309_310 309 310 4.632966e+00
R_310_311 310 311 6.815219e-01
R_311_312 311 312 8.913577e+00
R_312_313 312 313 2.196885e+00
R_313_314 313 314 5.017763e+00
R_314_315 314 315 1.856801e+00
R_315_316 315 316 1.988276e+00
R_316_317 316 317 2.112027e+00
R_317_318 317 318 1.603537e+00
R_318_319 318 319 9.402102e+00
R_319_320 319 320 9.385498e+00
R_320_321 320 321 5.502570e+00
R_321_322 321 322 2.655346e+00
R_322_323 322 323 3.548141e+00
R_323_324 323 324 8.973150e-01
R_324_325 324 325 9.714513e+00
R_325_326 325 326 1.883915e+00
R_326_327 326 327 4.601540e-01
R_327_328 327 328 7.405139e+00
R_328_329 328 329 2.918939e+00
R_329_330 329 330 3.190661e+00
R_330_331 330 331 7.315893e+00
R_331_332 331 332 8.455746e+00
R_332_333 332 333 5.622157e+00
R_333_334 333 334 9.507074e+00
R_334_335 334 335 9.513209e-01
R_335_336 335 336 5.512251e+00
R_336_337 336 337 8.106082e+00
R_337_338 337 338 8.462979e+00
R_338_339 338 339 5.985934e+00
R_339_340 339 340 1.226367e-01
R_340_341 340 341 9.381368e+00
R_341_342 341 342 5.224441e+00
R_342_343 342 343 2.939451e+00
R_343_344 343 344 3.464902e+00
R_344_345 344 345 5.304174e+00
R_345_346 345 346 7.733301e-01
R_346_347 346 347 7.154989e-01
R_347_348 347 348 4.774075e+00
R_348_349 348 349 5.795484e+00
R_349_350 349 350 3.812204e+00
R_350_351 350 351 2.282902e+00
R_351_352 351 352 1.356793e+00
R_352_353 352 353 6.402860e+00
R_353_354 353 354 7.718448e+00
R_354_355 354 355 1.870567e+00
R_355_356 355 356 5.803886e+00
R_356_357 356 357 3.155571e+00
R_357_358 357 358 2.669134e+00
R_358_359 358 359 8.810642e+00
R_359_360 359 360 4.447220e+00
R_360_361 360 361 4.099444e+00
R_361_362 361 362 4.878128e+00
R_362_363 362 363 5.399674e+00
R_363_364 363 364 5.343487e+00
R_364_365 364 365 9.094560e+00
R_365_366 365 366 9.776066e+00
R_366_367 366 367 3.120078e+00
R_367_368 367 368 6.201431e+00
R_368_369 368 369 7.318414e+00
R_369_370 369 370 3.745305e+00
R_370_371 370 371 2.617136e-01
R_371_372 371 372 9.846365e+00
R_372_373 372 373 4.433688e+00
R_373_374 373 374 4.410048e+00
R_374_375 374 375 9.102612e+00
R_375_376 375 376 5.091013e+00
R_376_377 376 377 1.058845e+00
R_377_378 377 378 1.859373e+00
R_378_379 378 379 2.747515e+00
R_379_380 379 380 2.545805e+00
R_380_381 380 381 2.406516e+00
R_381_382 381 382 7.213963e+00
R_382_383 382 383 3.479819e+00
R_383_384 383 384 1.212024e-01
R_384_385 384 385 4.544517e+00
R_385_386 385 386 4.730952e+00
R_386_387 386 387 4.068667e+00
R_387_388 387 388 5.211122e+00
R_388_389 388 389 6.094454e+00
R_389_390 389 390 1.825655e+00
R_390_391 390 391 1.059348e+00
R_391_392 391 392 7.939180e+00
R_392_393 392 393 8.344106e+00
R_393_394 393 394 3.346295e+00
R_394_395 394 395 2.690146e+00
R_395_396 395 396 3.310578e+00
R_396_397 396 397 1.360147e+00
R_397_398 397 398 4.680472e+00
R_398_399 398 399 3.455176e+00
R_399_400 399 400 7.167214e+00
R_401_402 401 402 6.977821e-01
R_402_403 402 403 6.225723e+00
R_403_404 403 404 8.244586e-01
R_404_405 404 405 6.675081e+00
R_405_406 405 406 6.180509e-01
R_406_407 406 407 6.436559e+00
R_407_408 407 408 8.047702e+00
R_408_409 408 409 6.201584e-02
R_409_410 409 410 4.067550e+00
R_410_411 410 411 1.124617e+00
R_411_412 411 412 1.530747e+00
R_412_413 412 413 7.390652e+00
R_413_414 413 414 1.305999e-01
R_414_415 414 415 3.083423e+00
R_415_416 415 416 7.686658e+00
R_416_417 416 417 6.659474e+00
R_417_418 417 418 8.513174e+00
R_418_419 418 419 2.456934e-01
R_419_420 419 420 3.496694e+00
R_420_421 420 421 9.481343e+00
R_421_422 421 422 4.843763e+00
R_422_423 422 423 4.920491e+00
R_423_424 423 424 4.631193e+00
R_424_425 424 425 8.369230e+00
R_425_426 425 426 5.220251e+00
R_426_427 426 427 4.583266e-01
R_427_428 427 428 7.608187e+00
R_428_429 428 429 5.548320e+00
R_429_430 429 430 2.076326e-01
R_430_431 430 431 9.161917e+00
R_431_432 431 432 7.203881e+00
R_432_433 432 433 5.950633e-01
R_433_434 433 434 2.946067e-01
R_434_435 434 435 6.296500e+00
R_435_436 435 436 8.486684e+00
R_436_437 436 437 6.666436e+00
R_437_438 437 438 5.631274e+00
R_438_439 438 439 9.655452e+00
R_439_440 439 440 9.194529e+00
R_440_441 440 441 3.252072e+00
R_441_442 441 442 5.541279e+00
R_442_443 442 443 3.415252e+00
R_443_444 443 444 6.835866e+00
R_444_445 444 445 3.442393e+00
R_445_446 445 446 1.801072e+00
R_446_447 446 447 5.882674e+00
R_447_448 447 448 9.243796e+00
R_448_449 448 449 5.273491e+00
R_449_450 449 450 7.434829e+00
R_450_451 450 451 2.945426e+00
R_451_452 451 452 5.893442e+00
R_452_453 452 453 4.766862e+00
R_453_454 453 454 4.142681e+00
R_454_455 454 455 8.515348e+00
R_455_456 455 456 6.332040e+00
R_456_457 456 457 9.517634e+00
R_457_458 457 458 5.789738e+00
R_458_459 458 459 6.144908e+00
R_459_460 459 460 2.980529e+00
R_460_461 460 461 3.872016e+00
R_461_462 461 462 5.469837e+00
R_462_463 462 463 7.601448e+00
R_463_464 463 464 1.060394e+00
R_464_465 464 465 6.006509e+00
R_465_466 465 466 9.174947e+00
R_466_467 466 467 6.251601e+00
R_467_468 467 468 7.913558e+00
R_468_469 468 469 8.299258e+00
R_469_470 469 470 3.527262e+00
R_470_471 470 471 1.507897e+00
R_471_472 471 472 5.862494e+00
R_472_473 472 473 6.213282e+00
R_473_474 473 474 4.984758e+00
R_474_475 474 475 7.058111e-01
R_475_476 475 476 7.918782e+00
R_476_477 476 477 8.580847e+00
R_477_478 477 478 7.549855e+00
R_478_479 478 479 4.394406e+00
R_479_480 479 480 4.625746e+00
R_480_481 480 481 4.157556e+00
R_481_482 481 482 8.154198e+00
R_482_483 482 483 8.098618e+00
R_483_484 483 484 6.718065e+00
R_484_485 484 485 6.576180e+00
R_485_486 485 486 7.617640e+00
R_486_487 486 487 3.832986e-01
R_487_488 487 488 6.355460e+00
R_488_489 488 489 2.390857e+00
R_489_490 489 490 6.714309e+00
R_490_491 490 491 6.782009e+00
R_491_492 491 492 4.891970e+00
R_492_493 492 493 4.500947e+00
R_493_494 493 494 6.644487e+00
R_494_495 494 495 8.473791e+00
R_495_496 495 496 1.165417e+00
R_496_497 496 497 9.178954e+00
R_497_498 497 498 5.386857e+00
R_498_499 498 499 1.349134e+00
R_499_500 499 500 4.121111e-01
R_501_502 501 502 9.062899e+00
R_502_503 502 503 6.622387e-01
R_503_504 503 504 4.546375e+00
R_504_505 504 505 2.476266e+00
R_505_506 505 506 5.726282e+00
R_506_507 506 507 9.072085e+00
R_507_508 507 508 1.985210e-01
R_508_509 508 509 1.885766e+00
R_509_510 509 510 9.080707e-01
R_510_511 510 511 5.850662e+00
R_511_512 511 512 4.823507e+00
R_512_513 512 513 5.150600e+00
R_513_514 513 514 6.235818e+00
R_514_515 514 515 6.670711e+00
R_515_516 515 516 3.249745e+00
R_516_517 516 517 2.144098e+00
R_517_518 517 518 6.375844e+00
R_518_519 518 519 8.717653e+00
R_519_520 519 520 6.133582e+00
R_520_521 520 521 9.437610e-01
R_521_522 521 522 7.346725e+00
R_522_523 522 523 5.420783e+00
R_523_524 523 524 8.686608e+00
R_524_525 524 525 7.461364e+00
R_525_526 525 526 5.616613e+00
R_526_527 526 527 7.900715e+00
R_527_528 527 528 3.505679e+00
R_528_529 528 529 1.013289e+00
R_529_530 529 530 2.199503e+00
R_530_531 530 531 5.494330e-01
R_531_532 531 532 5.259038e-01
R_532_533 532 533 4.614928e+00
R_533_534 533 534 6.363042e+00
R_534_535 534 535 8.698210e+00
R_535_536 535 536 5.692071e+00
R_536_537 536 537 7.161501e+00
R_537_538 537 538 5.230734e-01
R_538_539 538 539 9.182688e+00
R_539_540 539 540 4.837346e+00
R_540_541 540 541 9.076196e+00
R_541_542 541 542 9.033545e+00
R_542_543 542 543 2.664889e+00
R_543_544 543 544 9.163800e+00
R_544_545 544 545 4.734608e+00
R_545_546 545 546 3.442202e+00
R_546_547 546 547 6.355600e+00
R_547_548 547 548 9.600081e+00
R_548_549 548 549 1.089540e+00
R_549_550 549 550 9.410549e+00
R_550_551 550 551 4.197731e+00
R_551_552 551 552 6.506675e+00
R_552_553 552 553 1.803648e+00
R_553_554 553 554 6.088650e+00
R_554_555 554 555 8.618612e+00
R_555_556 555 556 7.925962e+00
R_556_557 556 557 9.834725e-01
R_557_558 557 558 9.989356e+00
R_558_559 558 559 7.404096e+00
R_559_560 559 560 2.284866e+00
R_560_561 560 561 9.361021e+00
R_561_562 561 562 2.761962e+00
R_562_563 562 563 2.884158e+00
R_563_564 563 564 7.305563e+00
R_564_565 564 565 5.102598e+00
R_565_566 565 566 1.512645e+00
R_566_567 566 567 4.651250e+00
R_567_568 567 568 4.271614e+00
R_568_569 568 569 5.956290e+00
R_569_570 569 570 5.974559e+00
R_570_571 570 571 4.203902e+00
R_571_572 571 572 6.464541e-02
R_572_573 572 573 1.384617e+00
R_573_574 573 574 2.702657e+00
R_574_575 574 575 3.240528e+00
R_575_576 575 576 2.991043e-01
R_576_577 576 577 7.294531e+00
R_577_578 577 578 1.496343e-01
R_578_579 578 579 5.710446e-01
R_579_580 579 580 2.789859e+00
R_580_581 580 581 7.441009e+00
R_581_582 581 582 7.062760e+00
R_582_583 582 583 8.444702e+00
R_583_584 583 584 1.500167e+00
R_584_585 584 585 8.193819e+00
R_585_586 585 586 6.475066e+00
R_586_587 586 587 9.879894e+00
R_587_588 587 588 5.736995e+00
R_588_589 588 589 7.850636e+00
R_589_590 589 590 1.738193e+00
R_590_591 590 591 8.548478e+00
R_591_592 591 592 4.530126e+00
R_592_593 592 593 7.023358e+00
R_593_594 593 594 7.193193e+00
R_594_595 594 595 8.420293e+00
R_595_596 595 596 8.041810e+00
R_596_597 596 597 2.396522e+00
R_597_598 597 598 8.581852e+00
R_598_599 598 599 5.235830e+00
R_599_600 599 600 5.240811e-01
R_601_602 601 602 2.141142e+00
R_602_603 602 603 5.131193e+00
R_603_604 603 604 7.156906e+00
R_604_605 604 605 1.521103e+00
R_605_606 605 606 8.184899e+00
R_606_607 606 607 2.970766e+00
R_607_608 607 608 2.147458e+00
R_608_609 608 609 1.806778e+00
R_609_610 609 610 2.031787e+00
R_610_611 610 611 4.288594e+00
R_611_612 611 612 5.259566e+00
R_612_613 612 613 6.884798e-01
R_613_614 613 614 9.414529e-01
R_614_615 614 615 7.312746e+00
R_615_616 615 616 7.082403e+00
R_616_617 616 617 2.613000e+00
R_617_618 617 618 2.191666e+00
R_618_619 618 619 1.277786e+00
R_619_620 619 620 6.394903e+00
R_620_621 620 621 7.666870e+00
R_621_622 621 622 9.143465e+00
R_622_623 622 623 3.998514e+00
R_623_624 623 624 8.000045e+00
R_624_625 624 625 4.413025e+00
R_625_626 625 626 3.755692e+00
R_626_627 626 627 2.891299e+00
R_627_628 627 628 1.372268e+00
R_628_629 628 629 9.149927e+00
R_629_630 629 630 6.465659e-01
R_630_631 630 631 2.624539e+00
R_631_632 631 632 7.219172e+00
R_632_633 632 633 4.087496e+00
R_633_634 633 634 4.269507e+00
R_634_635 634 635 9.236888e+00
R_635_636 635 636 4.278035e+00
R_636_637 636 637 5.743548e+00
R_637_638 637 638 7.345868e+00
R_638_639 638 639 3.642390e+00
R_639_640 639 640 8.672323e-01
R_640_641 640 641 8.789047e+00
R_641_642 641 642 8.652387e+00
R_642_643 642 643 3.808150e+00
R_643_644 643 644 1.787102e+00
R_644_645 644 645 5.678646e+00
R_645_646 645 646 8.287814e+00
R_646_647 646 647 7.515965e+00
R_647_648 647 648 3.456310e+00
R_648_649 648 649 7.293480e+00
R_649_650 649 650 1.149515e+00
R_650_651 650 651 9.588778e+00
R_651_652 651 652 8.298351e+00
R_652_653 652 653 6.390642e+00
R_653_654 653 654 6.487611e+00
R_654_655 654 655 8.014954e-01
R_655_656 655 656 9.659626e+00
R_656_657 656 657 1.609868e+00
R_657_658 657 658 6.596904e+00
R_658_659 658 659 8.998635e+00
R_659_660 659 660 1.903637e+00
R_660_661 660 661 1.252195e-01
R_661_662 661 662 5.693762e+00
R_662_663 662 663 2.916454e+00
R_663_664 663 664 6.590938e+00
R_664_665 664 665 5.683297e+00
R_665_666 665 666 2.453541e+00
R_666_667 666 667 9.072402e+00
R_667_668 667 668 3.839325e+00
R_668_669 668 669 2.919474e+00
R_669_670 669 670 3.997623e+00
R_670_671 670 671 6.826638e+00
R_671_672 671 672 4.045140e+00
R_672_673 672 673 6.126129e+00
R_673_674 673 674 4.935329e+00
R_674_675 674 675 3.610836e+00
R_675_676 675 676 9.467319e+00
R_676_677 676 677 1.177385e+00
R_677_678 677 678 5.685757e+00
R_678_679 678 679 3.517797e+00
R_679_680 679 680 9.550541e+00
R_680_681 680 681 5.881604e+00
R_681_682 681 682 3.199971e+00
R_682_683 682 683 1.772072e-01
R_683_684 683 684 7.677489e+00
R_684_685 684 685 5.417746e+00
R_685_686 685 686 2.058622e+00
R_686_687 686 687 2.389601e+00
R_687_688 687 688 5.928326e+00
R_688_689 688 689 1.104997e+00
R_689_690 689 690 9.126822e+00
R_690_691 690 691 4.434537e+00
R_691_692 691 692 4.029770e+00
R_692_693 692 693 4.664909e+00
R_693_694 693 694 8.654235e+00
R_694_695 694 695 4.697869e+00
R_695_696 695 696 8.455177e-01
R_696_697 696 697 9.621171e+00
R_697_698 697 698 9.989821e+00
R_698_699 698 699 4.298033e+00
R_699_700 699 700 5.021878e+00
R_701_702 701 702 6.931985e+00
R_702_703 702 703 1.868179e+00
R_703_704 703 704 6.045880e+00
R_704_705 704 705 3.437184e+00
R_705_706 705 706 7.542648e+00
R_706_707 706 707 8.192410e+00
R_707_708 707 708 3.702037e+00
R_708_709 708 709 8.853022e+00
R_709_710 709 710 9.687386e+00
R_710_711 710 711 8.316917e-01
R_711_712 711 712 1.676169e+00
R_712_713 712 713 7.688618e+00
R_713_714 713 714 1.028408e-01
R_714_715 714 715 7.013959e+00
R_715_716 715 716 4.497697e+00
R_716_717 716 717 7.428353e+00
R_717_718 717 718 7.208923e+00
R_718_719 718 719 2.115501e-01
R_719_720 719 720 2.464436e+00
R_720_721 720 721 9.601983e+00
R_721_722 721 722 3.528813e+00
R_722_723 722 723 7.017956e+00
R_723_724 723 724 7.457390e+00
R_724_725 724 725 6.670337e-02
R_725_726 725 726 1.892522e+00
R_726_727 726 727 7.587304e+00
R_727_728 727 728 4.511954e+00
R_728_729 728 729 1.211536e+00
R_729_730 729 730 2.449236e-01
R_730_731 730 731 3.454798e+00
R_731_732 731 732 4.819450e+00
R_732_733 732 733 7.198029e+00
R_733_734 733 734 9.943187e+00
R_734_735 734 735 1.175554e+00
R_735_736 735 736 8.310320e-01
R_736_737 736 737 4.795334e+00
R_737_738 737 738 1.501925e+00
R_738_739 738 739 4.645238e+00
R_739_740 739 740 9.623455e+00
R_740_741 740 741 6.054442e+00
R_741_742 741 742 4.290481e+00
R_742_743 742 743 3.355843e+00
R_743_744 743 744 5.714628e+00
R_744_745 744 745 1.971554e+00
R_745_746 745 746 5.374624e+00
R_746_747 746 747 4.812745e+00
R_747_748 747 748 5.452099e+00
R_748_749 748 749 5.544544e+00
R_749_750 749 750 6.740925e+00
R_750_751 750 751 4.858243e+00
R_751_752 751 752 5.643431e+00
R_752_753 752 753 8.186457e+00
R_753_754 753 754 9.055623e+00
R_754_755 754 755 6.194443e+00
R_755_756 755 756 8.801617e+00
R_756_757 756 757 7.016332e+00
R_757_758 757 758 1.785435e+00
R_758_759 758 759 9.125420e+00
R_759_760 759 760 6.993018e+00
R_760_761 760 761 2.384974e+00
R_761_762 761 762 9.794045e+00
R_762_763 762 763 4.943201e+00
R_763_764 763 764 5.872312e+00
R_764_765 764 765 3.498043e+00
R_765_766 765 766 3.909066e+00
R_766_767 766 767 9.427154e+00
R_767_768 767 768 1.258067e+00
R_768_769 768 769 9.677650e+00
R_769_770 769 770 1.412716e+00
R_770_771 770 771 2.675463e+00
R_771_772 771 772 7.917456e+00
R_772_773 772 773 1.186158e+00
R_773_774 773 774 4.035389e+00
R_774_775 774 775 1.463900e+00
R_775_776 775 776 5.035376e+00
R_776_777 776 777 2.274180e+00
R_777_778 777 778 3.793979e+00
R_778_779 778 779 8.988516e+00
R_779_780 779 780 7.679861e+00
R_780_781 780 781 9.467236e+00
R_781_782 781 782 1.557326e+00
R_782_783 782 783 1.004010e-01
R_783_784 783 784 5.968505e+00
R_784_785 784 785 5.175652e+00
R_785_786 785 786 2.238929e+00
R_786_787 786 787 7.119851e+00
R_787_788 787 788 9.728903e+00
R_788_789 788 789 6.836444e+00
R_789_790 789 790 6.484265e+00
R_790_791 790 791 8.246407e+00
R_791_792 791 792 2.948545e+00
R_792_793 792 793 3.510653e+00
R_793_794 793 794 3.591878e+00
R_794_795 794 795 4.019579e+00
R_795_796 795 796 9.995034e+00
R_796_797 796 797 8.237276e+00
R_797_798 797 798 7.697158e+00
R_798_799 798 799 2.827446e+00
R_799_800 799 800 7.053887e+00
R_801_802 801 802 1.349679e+00
R_802_803 802 803 1.061284e+00
R_803_804 803 804 7.268726e+00
R_804_805 804 805 2.576533e+00
R_805_806 805 806 4.413858e+00
R_806_807 806 807 5.530779e+00
R_807_808 807 808 7.540829e+00
R_808_809 808 809 5.987091e+00
R_809_810 809 810 5.992251e+00
R_810_811 810 811 3.416364e+00
R_811_812 811 812 6.833646e+00
R_812_813 812 813 7.209218e+00
R_813_814 813 814 8.495803e+00
R_814_815 814 815 5.462522e+00
R_815_816 815 816 1.180224e+00
R_816_817 816 817 6.095197e+00
R_817_818 817 818 9.866172e+00
R_818_819 818 819 1.579377e-01
R_819_820 819 820 2.475108e+00
R_820_821 820 821 4.820018e+00
R_821_822 821 822 8.804578e+00
R_822_823 822 823 5.009693e+00
R_823_824 823 824 2.379546e+00
R_824_825 824 825 9.901135e+00
R_825_826 825 826 7.292799e+00
R_826_827 826 827 6.502774e+00
R_827_828 827 828 1.381533e+00
R_828_829 828 829 2.467051e+00
R_829_830 829 830 6.800416e+00
R_830_831 830 831 7.214570e+00
R_831_832 831 832 7.505935e+00
R_832_833 832 833 5.891483e+00
R_833_834 833 834 7.167913e+00
R_834_835 834 835 1.202297e+00
R_835_836 835 836 9.858654e+00
R_836_837 836 837 1.742143e+00
R_837_838 837 838 6.219373e+00
R_838_839 838 839 3.855103e+00
R_839_840 839 840 2.326682e+00
R_840_841 840 841 8.054681e+00
R_841_842 841 842 4.346177e+00
R_842_843 842 843 8.458503e+00
R_843_844 843 844 6.038243e+00
R_844_845 844 845 1.972335e+00
R_845_846 845 846 6.697563e-01
R_846_847 846 847 9.582685e+00
R_847_848 847 848 5.489910e+00
R_848_849 848 849 8.238935e+00
R_849_850 849 850 6.418963e+00
R_850_851 850 851 7.058271e+00
R_851_852 851 852 1.378097e-01
R_852_853 852 853 5.882295e+00
R_853_854 853 854 3.081551e+00
R_854_855 854 855 8.656050e+00
R_855_856 855 856 6.923382e+00
R_856_857 856 857 5.984154e+00
R_857_858 857 858 8.391457e+00
R_858_859 858 859 7.386915e+00
R_859_860 859 860 9.024664e+00
R_860_861 860 861 4.530091e+00
R_861_862 861 862 4.200367e+00
R_862_863 862 863 2.495503e+00
R_863_864 863 864 4.307975e+00
R_864_865 864 865 3.443746e+00
R_865_866 865 866 5.206161e+00
R_866_867 866 867 9.658078e+00
R_867_868 867 868 3.712733e+00
R_868_869 868 869 1.503291e+00
R_869_870 869 870 5.377525e+00
R_870_871 870 871 3.915310e+00
R_871_872 871 872 6.750466e+00
R_872_873 872 873 2.490218e+00
R_873_874 873 874 2.155560e+00
R_874_875 874 875 7.339354e+00
R_875_876 875 876 3.198574e+00
R_876_877 876 877 6.736863e+00
R_877_878 877 878 4.141085e+00
R_878_879 878 879 9.186452e+00
R_879_880 879 880 9.705879e+00
R_880_881 880 881 8.374467e+00
R_881_882 881 882 4.493842e-01
R_882_883 882 883 2.405524e+00
R_883_884 883 884 7.365378e+00
R_884_885 884 885 2.898170e+00
R_885_886 885 886 6.109112e+00
R_886_887 886 887 9.084735e+00
R_887_888 887 888 8.919066e+00
R_888_889 888 889 9.669426e+00
R_889_890 889 890 3.246561e+00
R_890_891 890 891 8.598117e+00
R_891_892 891 892 8.051089e+00
R_892_893 892 893 2.624095e+00
R_893_894 893 894 7.509977e+00
R_894_895 894 895 7.126488e+00
R_895_896 895 896 2.593028e+00
R_896_897 896 897 8.765386e-01
R_897_898 897 898 2.775433e+00
R_898_899 898 899 3.677935e+00
R_899_900 899 900 9.089922e+00
R_901_902 901 902 4.755399e-01
R_902_903 902 903 1.720858e+00
R_903_904 903 904 1.762822e+00
R_904_905 904 905 3.060708e-01
R_905_906 905 906 4.958158e+00
R_906_907 906 907 4.704085e+00
R_907_908 907 908 4.654099e+00
R_908_909 908 909 7.400859e+00
R_909_910 909 910 2.601355e+00
R_910_911 910 911 7.084118e+00
R_911_912 911 912 2.042383e+00
R_912_913 912 913 6.864253e+00
R_913_914 913 914 8.343970e+00
R_914_915 914 915 8.861106e-01
R_915_916 915 916 3.696207e+00
R_916_917 916 917 8.876968e-01
R_917_918 917 918 6.048936e+00
R_918_919 918 919 3.400821e+00
R_919_920 919 920 3.250460e+00
R_920_921 920 921 9.725203e+00
R_921_922 921 922 5.870494e+00
R_922_923 922 923 5.541052e+00
R_923_924 923 924 5.953626e+00
R_924_925 924 925 9.481199e+00
R_925_926 925 926 6.176024e+00
R_926_927 926 927 6.305471e+00
R_927_928 927 928 9.302107e+00
R_928_929 928 929 2.875099e+00
R_929_930 929 930 3.022718e+00
R_930_931 930 931 2.925864e+00
R_931_932 931 932 7.462690e+00
R_932_933 932 933 1.760892e+00
R_933_934 933 934 5.776404e+00
R_934_935 934 935 3.044469e+00
R_935_936 935 936 5.762484e+00
R_936_937 936 937 9.555099e+00
R_937_938 937 938 1.946555e+00
R_938_939 938 939 9.320094e+00
R_939_940 939 940 6.489815e+00
R_940_941 940 941 9.359667e+00
R_941_942 941 942 6.586738e+00
R_942_943 942 943 8.616009e+00
R_943_944 943 944 9.378347e-01
R_944_945 944 945 1.641556e+00
R_945_946 945 946 1.427204e+00
R_946_947 946 947 8.272149e+00
R_947_948 947 948 6.253073e+00
R_948_949 948 949 3.944479e+00
R_949_950 949 950 1.523979e+00
R_950_951 950 951 2.297421e+00
R_951_952 951 952 3.756714e+00
R_952_953 952 953 1.055077e+00
R_953_954 953 954 9.140598e+00
R_954_955 954 955 8.743580e+00
R_955_956 955 956 6.070831e+00
R_956_957 956 957 5.857617e+00
R_957_958 957 958 7.708426e+00
R_958_959 958 959 6.514244e+00
R_959_960 959 960 6.806741e+00
R_960_961 960 961 8.787575e+00
R_961_962 961 962 5.197886e+00
R_962_963 962 963 4.329015e+00
R_963_964 963 964 4.929871e+00
R_964_965 964 965 6.589734e+00
R_965_966 965 966 5.371308e-01
R_966_967 966 967 2.915673e+00
R_967_968 967 968 1.678088e+00
R_968_969 968 969 7.028228e-01
R_969_970 969 970 7.762233e+00
R_970_971 970 971 2.100097e+00
R_971_972 971 972 1.909657e+00
R_972_973 972 973 3.179586e+00
R_973_974 973 974 9.301892e+00
R_974_975 974 975 5.561168e+00
R_975_976 975 976 1.310504e+00
R_976_977 976 977 8.546304e+00
R_977_978 977 978 7.697715e+00
R_978_979 978 979 1.089178e+00
R_979_980 979 980 7.349133e+00
R_980_981 980 981 3.823716e+00
R_981_982 981 982 5.511810e+00
R_982_983 982 983 1.691838e+00
R_983_984 983 984 8.962535e+00
R_984_985 984 985 7.988757e+00
R_985_986 985 986 6.670215e+00
R_986_987 986 987 4.284915e+00
R_987_988 987 988 9.012964e+00
R_988_989 988 989 6.884727e+00
R_989_990 989 990 7.132283e-01
R_990_991 990 991 8.492983e+00
R_991_992 991 992 6.288717e+00
R_992_993 992 993 9.205902e+00
R_993_994 993 994 1.308680e+00
R_994_995 994 995 3.262205e+00
R_995_996 995 996 1.060230e+00
R_996_997 996 997 1.635890e+00
R_997_998 997 998 5.339554e+00
R_998_999 998 999 7.328460e+00
R_999_1000 999 1000 4.539472e+00
R_1001_1002 1001 1002 8.114710e+00
R_1002_1003 1002 1003 1.017110e+00
R_1003_1004 1003 1004 6.636891e+00
R_1004_1005 1004 1005 7.346392e+00
R_1005_1006 1005 1006 6.358615e+00
R_1006_1007 1006 1007 4.958700e+00
R_1007_1008 1007 1008 8.285324e+00
R_1008_1009 1008 1009 7.161594e+00
R_1009_1010 1009 1010 8.382374e+00
R_1010_1011 1010 1011 3.456579e+00
R_1011_1012 1011 1012 1.580205e+00
R_1012_1013 1012 1013 1.076079e+00
R_1013_1014 1013 1014 4.118907e-01
R_1014_1015 1014 1015 7.326786e+00
R_1015_1016 1015 1016 8.870182e+00
R_1016_1017 1016 1017 2.097641e+00
R_1017_1018 1017 1018 6.738999e+00
R_1018_1019 1018 1019 2.523554e+00
R_1019_1020 1019 1020 4.134023e-01
R_1020_1021 1020 1021 7.619935e+00
R_1021_1022 1021 1022 8.203683e+00
R_1022_1023 1022 1023 8.385963e+00
R_1023_1024 1023 1024 7.780540e+00
R_1024_1025 1024 1025 1.689299e+00
R_1025_1026 1025 1026 4.710890e+00
R_1026_1027 1026 1027 2.774893e+00
R_1027_1028 1027 1028 8.668166e+00
R_1028_1029 1028 1029 9.062983e+00
R_1029_1030 1029 1030 4.521977e+00
R_1030_1031 1030 1031 7.875956e+00
R_1031_1032 1031 1032 9.835204e+00
R_1032_1033 1032 1033 4.474867e+00
R_1033_1034 1033 1034 8.749479e+00
R_1034_1035 1034 1035 8.935515e+00
R_1035_1036 1035 1036 5.587381e+00
R_1036_1037 1036 1037 9.513789e+00
R_1037_1038 1037 1038 4.951878e+00
R_1038_1039 1038 1039 8.834279e+00
R_1039_1040 1039 1040 6.332145e+00
R_1040_1041 1040 1041 4.782132e+00
R_1041_1042 1041 1042 8.484431e+00
R_1042_1043 1042 1043 6.831008e+00
R_1043_1044 1043 1044 1.763829e-01
R_1044_1045 1044 1045 1.721161e-01
R_1045_1046 1045 1046 2.067702e+00
R_1046_1047 1046 1047 5.546272e+00
R_1047_1048 1047 1048 6.257205e+00
R_1048_1049 1048 1049 7.619221e+00
R_1049_1050 1049 1050 4.567605e+00
R_1050_1051 1050 1051 4.422116e+00
R_1051_1052 1051 1052 9.916022e+00
R_1052_1053 1052 1053 3.403423e-01
R_1053_1054 1053 1054 7.768692e+00
R_1054_1055 1054 1055 7.406469e+00
R_1055_1056 1055 1056 3.904426e+00
R_1056_1057 1056 1057 3.776656e-01
R_1057_1058 1057 1058 5.323288e+00
R_1058_1059 1058 1059 2.258492e+00
R_1059_1060 1059 1060 8.629803e+00
R_1060_1061 1060 1061 1.572655e+00
R_1061_1062 1061 1062 7.407979e-01
R_1062_1063 1062 1063 5.524872e+00
R_1063_1064 1063 1064 2.217631e-01
R_1064_1065 1064 1065 4.540598e+00
R_1065_1066 1065 1066 9.716497e-02
R_1066_1067 1066 1067 1.338919e+00
R_1067_1068 1067 1068 1.891539e+00
R_1068_1069 1068 1069 5.581794e+00
R_1069_1070 1069 1070 6.815344e+00
R_1070_1071 1070 1071 8.337897e+00
R_1071_1072 1071 1072 5.285983e+00
R_1072_1073 1072 1073 1.012329e+00
R_1073_1074 1073 1074 6.602951e+00
R_1074_1075 1074 1075 3.697002e+00
R_1075_1076 1075 1076 6.318237e+00
R_1076_1077 1076 1077 4.328924e+00
R_1077_1078 1077 1078 9.221373e+00
R_1078_1079 1078 1079 8.748460e+00
R_1079_1080 1079 1080 8.819441e-01
R_1080_1081 1080 1081 2.139167e+00
R_1081_1082 1081 1082 5.379549e+00
R_1082_1083 1082 1083 5.211245e+00
R_1083_1084 1083 1084 7.289126e+00
R_1084_1085 1084 1085 9.799000e+00
R_1085_1086 1085 1086 4.056900e+00
R_1086_1087 1086 1087 9.087050e+00
R_1087_1088 1087 1088 2.702025e-01
R_1088_1089 1088 1089 1.362632e+00
R_1089_1090 1089 1090 1.879589e-01
R_1090_1091 1090 1091 6.768209e+00
R_1091_1092 1091 1092 7.006729e+00
R_1092_1093 1092 1093 8.492442e+00
R_1093_1094 1093 1094 8.672646e+00
R_1094_1095 1094 1095 3.530899e+00
R_1095_1096 1095 1096 1.037651e+00
R_1096_1097 1096 1097 2.999548e+00
R_1097_1098 1097 1098 6.183512e+00
R_1098_1099 1098 1099 3.708270e+00
R_1099_1100 1099 1100 3.694171e-01
R_1101_1102 1101 1102 3.616955e-01
R_1102_1103 1102 1103 5.230841e+00
R_1103_1104 1103 1104 5.032247e+00
R_1104_1105 1104 1105 8.274513e+00
R_1105_1106 1105 1106 6.509273e+00
R_1106_1107 1106 1107 5.378782e+00
R_1107_1108 1107 1108 3.064340e-01
R_1108_1109 1108 1109 8.996458e-01
R_1109_1110 1109 1110 5.879730e-01
R_1110_1111 1110 1111 8.973128e+00
R_1111_1112 1111 1112 9.452200e+00
R_1112_1113 1112 1113 3.923270e+00
R_1113_1114 1113 1114 7.539379e+00
R_1114_1115 1114 1115 5.297772e+00
R_1115_1116 1115 1116 1.433551e+00
R_1116_1117 1116 1117 9.057856e+00
R_1117_1118 1117 1118 9.130660e+00
R_1118_1119 1118 1119 3.757907e+00
R_1119_1120 1119 1120 3.050356e+00
R_1120_1121 1120 1121 5.998455e+00
R_1121_1122 1121 1122 9.883667e+00
R_1122_1123 1122 1123 3.309864e+00
R_1123_1124 1123 1124 3.478221e+00
R_1124_1125 1124 1125 6.162879e-01
R_1125_1126 1125 1126 8.557724e+00
R_1126_1127 1126 1127 1.460363e+00
R_1127_1128 1127 1128 8.696860e-01
R_1128_1129 1128 1129 2.937432e+00
R_1129_1130 1129 1130 8.756611e+00
R_1130_1131 1130 1131 6.900585e+00
R_1131_1132 1131 1132 4.224402e+00
R_1132_1133 1132 1133 8.389383e+00
R_1133_1134 1133 1134 8.414302e+00
R_1134_1135 1134 1135 9.732410e+00
R_1135_1136 1135 1136 2.705158e+00
R_1136_1137 1136 1137 9.071501e+00
R_1137_1138 1137 1138 7.562085e+00
R_1138_1139 1138 1139 7.291277e+00
R_1139_1140 1139 1140 1.298096e+00
R_1140_1141 1140 1141 7.146883e+00
R_1141_1142 1141 1142 4.911052e+00
R_1142_1143 1142 1143 8.687135e+00
R_1143_1144 1143 1144 4.665562e+00
R_1144_1145 1144 1145 3.113558e+00
R_1145_1146 1145 1146 8.825200e+00
R_1146_1147 1146 1147 1.560527e+00
R_1147_1148 1147 1148 8.670456e+00
R_1148_1149 1148 1149 3.129505e-01
R_1149_1150 1149 1150 1.450718e+00
R_1150_1151 1150 1151 6.100850e+00
R_1151_1152 1151 1152 2.794650e+00
R_1152_1153 1152 1153 3.318518e+00
R_1153_1154 1153 1154 4.285949e+00
R_1154_1155 1154 1155 6.261782e+00
R_1155_1156 1155 1156 8.703886e+00
R_1156_1157 1156 1157 9.112194e+00
R_1157_1158 1157 1158 9.459896e-01
R_1158_1159 1158 1159 7.540078e+00
R_1159_1160 1159 1160 8.933409e+00
R_1160_1161 1160 1161 4.675546e+00
R_1161_1162 1161 1162 7.136346e+00
R_1162_1163 1162 1163 7.518708e+00
R_1163_1164 1163 1164 8.259703e-01
R_1164_1165 1164 1165 6.722219e+00
R_1165_1166 1165 1166 1.470085e+00
R_1166_1167 1166 1167 3.029361e+00
R_1167_1168 1167 1168 6.928191e+00
R_1168_1169 1168 1169 4.854622e+00
R_1169_1170 1169 1170 2.152030e+00
R_1170_1171 1170 1171 3.957932e+00
R_1171_1172 1171 1172 4.782915e+00
R_1172_1173 1172 1173 6.309268e+00
R_1173_1174 1173 1174 5.029729e+00
R_1174_1175 1174 1175 1.106674e+00
R_1175_1176 1175 1176 5.741093e+00
R_1176_1177 1176 1177 4.624913e+00
R_1177_1178 1177 1178 3.059869e-01
R_1178_1179 1178 1179 6.936081e+00
R_1179_1180 1179 1180 6.307541e+00
R_1180_1181 1180 1181 9.397264e+00
R_1181_1182 1181 1182 3.976452e+00
R_1182_1183 1182 1183 1.658112e+00
R_1183_1184 1183 1184 5.611391e-01
R_1184_1185 1184 1185 7.940581e+00
R_1185_1186 1185 1186 1.502308e+00
R_1186_1187 1186 1187 9.896009e+00
R_1187_1188 1187 1188 9.903834e+00
R_1188_1189 1188 1189 3.164447e+00
R_1189_1190 1189 1190 8.689711e+00
R_1190_1191 1190 1191 3.870784e+00
R_1191_1192 1191 1192 7.474245e+00
R_1192_1193 1192 1193 9.336877e+00
R_1193_1194 1193 1194 6.500914e+00
R_1194_1195 1194 1195 2.164482e+00
R_1195_1196 1195 1196 1.152066e+00
R_1196_1197 1196 1197 9.269660e+00
R_1197_1198 1197 1198 2.377942e+00
R_1198_1199 1198 1199 5.086158e+00
R_1199_1200 1199 1200 2.088854e+00
R_1201_1202 1201 1202 2.727025e+00
R_1202_1203 1202 1203 3.584163e+00
R_1203_1204 1203 1204 1.623438e+00
R_1204_1205 1204 1205 5.409315e+00
R_1205_1206 1205 1206 1.663784e+00
R_1206_1207 1206 1207 4.372625e+00
R_1207_1208 1207 1208 5.669187e+00
R_1208_1209 1208 1209 9.392648e+00
R_1209_1210 1209 1210 2.457096e+00
R_1210_1211 1210 1211 8.811786e+00
R_1211_1212 1211 1212 8.851866e+00
R_1212_1213 1212 1213 8.197293e+00
R_1213_1214 1213 1214 8.353785e-01
R_1214_1215 1214 1215 3.357463e+00
R_1215_1216 1215 1216 3.739889e+00
R_1216_1217 1216 1217 7.694832e-01
R_1217_1218 1217 1218 1.724109e+00
R_1218_1219 1218 1219 1.642224e+00
R_1219_1220 1219 1220 2.702817e+00
R_1220_1221 1220 1221 6.055416e+00
R_1221_1222 1221 1222 8.863414e+00
R_1222_1223 1222 1223 5.851443e+00
R_1223_1224 1223 1224 7.982112e-03
R_1224_1225 1224 1225 7.134827e+00
R_1225_1226 1225 1226 9.574319e+00
R_1226_1227 1226 1227 6.285420e+00
R_1227_1228 1227 1228 7.130143e+00
R_1228_1229 1228 1229 2.913477e+00
R_1229_1230 1229 1230 4.791124e+00
R_1230_1231 1230 1231 2.185472e+00
R_1231_1232 1231 1232 5.686704e+00
R_1232_1233 1232 1233 9.000602e+00
R_1233_1234 1233 1234 3.714762e-01
R_1234_1235 1234 1235 8.720036e+00
R_1235_1236 1235 1236 3.327000e+00
R_1236_1237 1236 1237 2.470202e+00
R_1237_1238 1237 1238 8.981788e+00
R_1238_1239 1238 1239 9.585651e+00
R_1239_1240 1239 1240 3.113886e-01
R_1240_1241 1240 1241 9.343595e+00
R_1241_1242 1241 1242 3.730603e+00
R_1242_1243 1242 1243 4.850877e+00
R_1243_1244 1243 1244 6.766246e-01
R_1244_1245 1244 1245 9.375698e+00
R_1245_1246 1245 1246 1.162941e-01
R_1246_1247 1246 1247 1.388865e+00
R_1247_1248 1247 1248 2.912766e+00
R_1248_1249 1248 1249 3.707732e+00
R_1249_1250 1249 1250 3.910345e+00
R_1250_1251 1250 1251 1.037247e+00
R_1251_1252 1251 1252 8.432742e-01
R_1252_1253 1252 1253 4.453643e+00
R_1253_1254 1253 1254 2.287061e+00
R_1254_1255 1254 1255 8.358563e+00
R_1255_1256 1255 1256 5.781956e+00
R_1256_1257 1256 1257 7.909532e+00
R_1257_1258 1257 1258 8.119678e+00
R_1258_1259 1258 1259 8.723315e+00
R_1259_1260 1259 1260 1.575393e+00
R_1260_1261 1260 1261 5.649884e+00
R_1261_1262 1261 1262 9.752072e+00
R_1262_1263 1262 1263 7.983917e+00
R_1263_1264 1263 1264 2.783441e+00
R_1264_1265 1264 1265 2.081473e+00
R_1265_1266 1265 1266 5.866467e+00
R_1266_1267 1266 1267 6.151420e+00
R_1267_1268 1267 1268 9.420043e+00
R_1268_1269 1268 1269 7.208101e+00
R_1269_1270 1269 1270 1.534248e+00
R_1270_1271 1270 1271 7.966581e+00
R_1271_1272 1271 1272 3.408048e-02
R_1272_1273 1272 1273 4.977167e+00
R_1273_1274 1273 1274 2.279106e+00
R_1274_1275 1274 1275 7.362028e+00
R_1275_1276 1275 1276 6.876510e+00
R_1276_1277 1276 1277 4.696243e+00
R_1277_1278 1277 1278 3.478060e+00
R_1278_1279 1278 1279 3.737769e-01
R_1279_1280 1279 1280 9.654452e+00
R_1280_1281 1280 1281 1.088190e+00
R_1281_1282 1281 1282 9.438191e+00
R_1282_1283 1282 1283 4.398665e+00
R_1283_1284 1283 1284 6.614173e+00
R_1284_1285 1284 1285 5.738328e+00
R_1285_1286 1285 1286 5.190493e+00
R_1286_1287 1286 1287 1.580508e+00
R_1287_1288 1287 1288 2.423962e+00
R_1288_1289 1288 1289 3.647094e+00
R_1289_1290 1289 1290 7.203802e+00
R_1290_1291 1290 1291 1.802032e+00
R_1291_1292 1291 1292 9.491213e+00
R_1292_1293 1292 1293 3.767434e-01
R_1293_1294 1293 1294 4.371084e+00
R_1294_1295 1294 1295 5.527005e+00
R_1295_1296 1295 1296 6.907763e+00
R_1296_1297 1296 1297 2.471723e+00
R_1297_1298 1297 1298 2.901259e+00
R_1298_1299 1298 1299 6.371487e+00
R_1299_1300 1299 1300 2.480215e+00
R_1301_1302 1301 1302 5.185725e+00
R_1302_1303 1302 1303 1.516400e+00
R_1303_1304 1303 1304 4.158388e+00
R_1304_1305 1304 1305 7.660510e+00
R_1305_1306 1305 1306 7.248683e+00
R_1306_1307 1306 1307 8.090541e+00
R_1307_1308 1307 1308 7.681289e-01
R_1308_1309 1308 1309 1.697857e+00
R_1309_1310 1309 1310 7.646906e+00
R_1310_1311 1310 1311 9.169487e+00
R_1311_1312 1311 1312 7.249749e+00
R_1312_1313 1312 1313 1.926087e-01
R_1313_1314 1313 1314 4.247852e+00
R_1314_1315 1314 1315 1.881671e+00
R_1315_1316 1315 1316 6.072692e+00
R_1316_1317 1316 1317 6.369356e+00
R_1317_1318 1317 1318 4.948993e+00
R_1318_1319 1318 1319 3.229410e+00
R_1319_1320 1319 1320 6.187914e+00
R_1320_1321 1320 1321 1.525817e+00
R_1321_1322 1321 1322 7.780367e+00
R_1322_1323 1322 1323 8.460566e+00
R_1323_1324 1323 1324 5.615503e+00
R_1324_1325 1324 1325 1.329866e+00
R_1325_1326 1325 1326 6.844162e+00
R_1326_1327 1326 1327 2.411399e+00
R_1327_1328 1327 1328 8.204392e+00
R_1328_1329 1328 1329 2.706752e+00
R_1329_1330 1329 1330 1.799672e+00
R_1330_1331 1330 1331 3.171232e+00
R_1331_1332 1331 1332 8.376597e+00
R_1332_1333 1332 1333 6.695306e+00
R_1333_1334 1333 1334 8.746478e+00
R_1334_1335 1334 1335 6.467098e+00
R_1335_1336 1335 1336 3.336471e+00
R_1336_1337 1336 1337 7.088646e+00
R_1337_1338 1337 1338 1.413602e+00
R_1338_1339 1338 1339 8.425169e+00
R_1339_1340 1339 1340 5.962630e+00
R_1340_1341 1340 1341 5.714505e+00
R_1341_1342 1341 1342 4.910060e-01
R_1342_1343 1342 1343 6.624637e+00
R_1343_1344 1343 1344 2.399797e-01
R_1344_1345 1344 1345 3.222753e+00
R_1345_1346 1345 1346 4.008439e+00
R_1346_1347 1346 1347 6.336357e+00
R_1347_1348 1347 1348 5.131249e+00
R_1348_1349 1348 1349 5.204558e+00
R_1349_1350 1349 1350 6.616074e+00
R_1350_1351 1350 1351 8.769242e+00
R_1351_1352 1351 1352 3.907795e+00
R_1352_1353 1352 1353 2.802906e-01
R_1353_1354 1353 1354 8.693098e+00
R_1354_1355 1354 1355 2.781126e+00
R_1355_1356 1355 1356 6.935095e+00
R_1356_1357 1356 1357 1.374951e+00
R_1357_1358 1357 1358 2.294876e+00
R_1358_1359 1358 1359 3.253347e+00
R_1359_1360 1359 1360 5.443420e+00
R_1360_1361 1360 1361 1.906697e+00
R_1361_1362 1361 1362 7.428582e+00
R_1362_1363 1362 1363 8.672573e+00
R_1363_1364 1363 1364 9.868977e+00
R_1364_1365 1364 1365 9.749547e+00
R_1365_1366 1365 1366 7.441942e+00
R_1366_1367 1366 1367 8.164241e+00
R_1367_1368 1367 1368 9.808818e+00
R_1368_1369 1368 1369 6.112066e+00
R_1369_1370 1369 1370 1.100258e+00
R_1370_1371 1370 1371 1.114623e+00
R_1371_1372 1371 1372 1.505703e-01
R_1372_1373 1372 1373 1.561964e+00
R_1373_1374 1373 1374 7.846430e-01
R_1374_1375 1374 1375 2.583949e+00
R_1375_1376 1375 1376 3.952733e-01
R_1376_1377 1376 1377 9.186473e-01
R_1377_1378 1377 1378 2.579510e-01
R_1378_1379 1378 1379 9.007501e+00
R_1379_1380 1379 1380 2.667700e+00
R_1380_1381 1380 1381 2.415563e+00
R_1381_1382 1381 1382 8.619527e+00
R_1382_1383 1382 1383 3.003514e+00
R_1383_1384 1383 1384 9.634912e+00
R_1384_1385 1384 1385 9.995814e+00
R_1385_1386 1385 1386 9.173648e+00
R_1386_1387 1386 1387 3.560469e+00
R_1387_1388 1387 1388 3.575265e+00
R_1388_1389 1388 1389 5.559881e+00
R_1389_1390 1389 1390 6.181578e+00
R_1390_1391 1390 1391 6.765340e+00
R_1391_1392 1391 1392 3.291072e+00
R_1392_1393 1392 1393 3.480026e+00
R_1393_1394 1393 1394 5.555590e+00
R_1394_1395 1394 1395 5.144263e+00
R_1395_1396 1395 1396 5.575365e+00
R_1396_1397 1396 1397 1.113921e-02
R_1397_1398 1397 1398 9.038537e+00
R_1398_1399 1398 1399 1.539015e+00
R_1399_1400 1399 1400 2.496301e+00
R_1401_1402 1401 1402 1.214162e+00
R_1402_1403 1402 1403 9.091686e+00
R_1403_1404 1403 1404 5.667536e+00
R_1404_1405 1404 1405 4.519124e+00
R_1405_1406 1405 1406 5.942826e+00
R_1406_1407 1406 1407 3.950172e+00
R_1407_1408 1407 1408 6.791595e+00
R_1408_1409 1408 1409 5.102544e+00
R_1409_1410 1409 1410 9.746267e+00
R_1410_1411 1410 1411 2.835504e-01
R_1411_1412 1411 1412 8.928791e+00
R_1412_1413 1412 1413 6.849923e-01
R_1413_1414 1413 1414 5.594951e+00
R_1414_1415 1414 1415 9.138059e+00
R_1415_1416 1415 1416 7.288318e+00
R_1416_1417 1416 1417 8.221985e+00
R_1417_1418 1417 1418 6.721932e+00
R_1418_1419 1418 1419 8.741095e+00
R_1419_1420 1419 1420 8.431693e+00
R_1420_1421 1420 1421 7.368675e+00
R_1421_1422 1421 1422 6.844489e+00
R_1422_1423 1422 1423 3.895500e+00
R_1423_1424 1423 1424 9.036457e-01
R_1424_1425 1424 1425 4.805379e+00
R_1425_1426 1425 1426 4.244114e+00
R_1426_1427 1426 1427 7.203994e+00
R_1427_1428 1427 1428 9.284388e+00
R_1428_1429 1428 1429 1.191892e+00
R_1429_1430 1429 1430 1.896636e+00
R_1430_1431 1430 1431 4.806483e+00
R_1431_1432 1431 1432 2.896265e+00
R_1432_1433 1432 1433 4.765410e+00
R_1433_1434 1433 1434 5.855843e+00
R_1434_1435 1434 1435 6.531751e-01
R_1435_1436 1435 1436 6.653589e+00
R_1436_1437 1436 1437 2.661291e+00
R_1437_1438 1437 1438 7.205290e-01
R_1438_1439 1438 1439 5.257123e+00
R_1439_1440 1439 1440 6.272839e+00
R_1440_1441 1440 1441 1.801421e+00
R_1441_1442 1441 1442 1.519150e+00
R_1442_1443 1442 1443 9.399809e+00
R_1443_1444 1443 1444 5.272836e+00
R_1444_1445 1444 1445 8.109083e+00
R_1445_1446 1445 1446 5.038920e+00
R_1446_1447 1446 1447 3.198801e+00
R_1447_1448 1447 1448 7.616388e+00
R_1448_1449 1448 1449 7.829800e+00
R_1449_1450 1449 1450 2.220869e+00
R_1450_1451 1450 1451 5.586773e+00
R_1451_1452 1451 1452 8.080616e+00
R_1452_1453 1452 1453 5.738152e+00
R_1453_1454 1453 1454 8.403071e+00
R_1454_1455 1454 1455 9.575248e+00
R_1455_1456 1455 1456 3.615441e+00
R_1456_1457 1456 1457 1.182670e+00
R_1457_1458 1457 1458 1.724858e+00
R_1458_1459 1458 1459 6.610620e-01
R_1459_1460 1459 1460 8.809780e+00
R_1460_1461 1460 1461 9.209193e+00
R_1461_1462 1461 1462 3.950335e+00
R_1462_1463 1462 1463 7.794964e+00
R_1463_1464 1463 1464 7.234455e+00
R_1464_1465 1464 1465 4.128181e+00
R_1465_1466 1465 1466 7.199485e+00
R_1466_1467 1466 1467 2.436251e+00
R_1467_1468 1467 1468 7.523338e+00
R_1468_1469 1468 1469 7.583284e+00
R_1469_1470 1469 1470 2.480396e+00
R_1470_1471 1470 1471 9.861536e+00
R_1471_1472 1471 1472 2.365578e+00
R_1472_1473 1472 1473 1.369827e+00
R_1473_1474 1473 1474 3.701784e+00
R_1474_1475 1474 1475 8.167202e+00
R_1475_1476 1475 1476 5.842579e+00
R_1476_1477 1476 1477 6.823816e+00
R_1477_1478 1477 1478 1.419265e+00
R_1478_1479 1478 1479 5.053976e+00
R_1479_1480 1479 1480 5.192605e+00
R_1480_1481 1480 1481 5.534141e+00
R_1481_1482 1481 1482 9.468245e+00
R_1482_1483 1482 1483 4.718015e+00
R_1483_1484 1483 1484 6.774358e+00
R_1484_1485 1484 1485 1.128083e+00
R_1485_1486 1485 1486 8.518651e+00
R_1486_1487 1486 1487 5.846375e+00
R_1487_1488 1487 1488 4.514942e+00
R_1488_1489 1488 1489 2.896408e+00
R_1489_1490 1489 1490 5.139385e-01
R_1490_1491 1490 1491 7.375883e+00
R_1491_1492 1491 1492 2.279606e+00
R_1492_1493 1492 1493 2.737262e+00
R_1493_1494 1493 1494 5.564608e+00
R_1494_1495 1494 1495 4.734247e+00
R_1495_1496 1495 1496 9.452611e+00
R_1496_1497 1496 1497 8.041667e+00
R_1497_1498 1497 1498 6.801474e+00
R_1498_1499 1498 1499 3.331621e+00
R_1499_1500 1499 1500 6.538721e-01
R_1501_1502 1501 1502 5.847915e-01
R_1502_1503 1502 1503 8.674826e+00
R_1503_1504 1503 1504 5.311817e+00
R_1504_1505 1504 1505 5.106584e+00
R_1505_1506 1505 1506 2.894416e+00
R_1506_1507 1506 1507 5.721936e+00
R_1507_1508 1507 1508 4.581576e+00
R_1508_1509 1508 1509 2.535722e-01
R_1509_1510 1509 1510 3.837642e+00
R_1510_1511 1510 1511 8.012634e+00
R_1511_1512 1511 1512 6.439475e+00
R_1512_1513 1512 1513 3.834259e+00
R_1513_1514 1513 1514 8.196455e+00
R_1514_1515 1514 1515 1.185393e+00
R_1515_1516 1515 1516 3.305048e-01
R_1516_1517 1516 1517 5.761376e+00
R_1517_1518 1517 1518 2.859436e+00
R_1518_1519 1518 1519 1.902975e-01
R_1519_1520 1519 1520 9.467650e+00
R_1520_1521 1520 1521 8.863389e-01
R_1521_1522 1521 1522 3.831488e+00
R_1522_1523 1522 1523 8.205592e+00
R_1523_1524 1523 1524 6.405097e+00
R_1524_1525 1524 1525 6.473198e+00
R_1525_1526 1525 1526 1.110489e+00
R_1526_1527 1526 1527 4.195926e+00
R_1527_1528 1527 1528 1.448540e+00
R_1528_1529 1528 1529 5.241284e-01
R_1529_1530 1529 1530 9.341660e+00
R_1530_1531 1530 1531 6.858214e+00
R_1531_1532 1531 1532 3.160791e+00
R_1532_1533 1532 1533 1.283998e+00
R_1533_1534 1533 1534 6.442499e-01
R_1534_1535 1534 1535 4.991823e+00
R_1535_1536 1535 1536 8.632829e+00
R_1536_1537 1536 1537 4.836161e+00
R_1537_1538 1537 1538 2.941519e+00
R_1538_1539 1538 1539 5.951822e+00
R_1539_1540 1539 1540 8.437958e+00
R_1540_1541 1540 1541 2.859374e-01
R_1541_1542 1541 1542 3.736064e+00
R_1542_1543 1542 1543 4.492522e+00
R_1543_1544 1543 1544 6.834200e+00
R_1544_1545 1544 1545 4.458178e+00
R_1545_1546 1545 1546 3.887317e+00
R_1546_1547 1546 1547 4.724377e+00
R_1547_1548 1547 1548 2.747616e-01
R_1548_1549 1548 1549 4.732890e+00
R_1549_1550 1549 1550 9.401880e+00
R_1550_1551 1550 1551 8.509830e+00
R_1551_1552 1551 1552 7.002068e+00
R_1552_1553 1552 1553 1.695459e+00
R_1553_1554 1553 1554 9.089076e+00
R_1554_1555 1554 1555 3.399777e+00
R_1555_1556 1555 1556 4.726709e+00
R_1556_1557 1556 1557 9.578416e+00
R_1557_1558 1557 1558 1.679083e-01
R_1558_1559 1558 1559 3.810836e+00
R_1559_1560 1559 1560 2.496789e-01
R_1560_1561 1560 1561 8.249416e+00
R_1561_1562 1561 1562 9.624612e+00
R_1562_1563 1562 1563 4.644778e-01
R_1563_1564 1563 1564 9.058391e+00
R_1564_1565 1564 1565 9.527979e+00
R_1565_1566 1565 1566 3.181127e+00
R_1566_1567 1566 1567 2.293980e+00
R_1567_1568 1567 1568 9.534865e+00
R_1568_1569 1568 1569 3.660108e+00
R_1569_1570 1569 1570 2.624639e+00
R_1570_1571 1570 1571 8.767565e+00
R_1571_1572 1571 1572 4.339244e+00
R_1572_1573 1572 1573 4.187642e+00
R_1573_1574 1573 1574 8.057226e+00
R_1574_1575 1574 1575 8.902018e+00
R_1575_1576 1575 1576 5.784713e+00
R_1576_1577 1576 1577 3.849829e-01
R_1577_1578 1577 1578 3.427890e+00
R_1578_1579 1578 1579 2.723721e-01
R_1579_1580 1579 1580 1.149924e+00
R_1580_1581 1580 1581 7.253310e+00
R_1581_1582 1581 1582 1.910975e+00
R_1582_1583 1582 1583 4.380038e-01
R_1583_1584 1583 1584 9.907258e+00
R_1584_1585 1584 1585 8.630848e+00
R_1585_1586 1585 1586 4.077551e+00
R_1586_1587 1586 1587 3.350654e+00
R_1587_1588 1587 1588 4.180229e+00
R_1588_1589 1588 1589 9.063739e+00
R_1589_1590 1589 1590 4.607565e+00
R_1590_1591 1590 1591 5.198419e+00
R_1591_1592 1591 1592 7.541227e+00
R_1592_1593 1592 1593 2.909418e+00
R_1593_1594 1593 1594 1.598206e+00
R_1594_1595 1594 1595 8.019837e+00
R_1595_1596 1595 1596 9.904934e+00
R_1596_1597 1596 1597 6.843016e+00
R_1597_1598 1597 1598 6.682324e+00
R_1598_1599 1598 1599 7.723302e+00
R_1599_1600 1599 1600 7.434422e+00
R_1601_1602 1601 1602 8.626320e+00
R_1602_1603 1602 1603 9.688105e+00
R_1603_1604 1603 1604 6.092520e+00
R_1604_1605 1604 1605 3.941355e+00
R_1605_1606 1605 1606 7.985369e+00
R_1606_1607 1606 1607 2.807175e-01
R_1607_1608 1607 1608 2.609964e+00
R_1608_1609 1608 1609 2.322287e-01
R_1609_1610 1609 1610 6.636910e+00
R_1610_1611 1610 1611 2.409473e+00
R_1611_1612 1611 1612 2.542618e+00
R_1612_1613 1612 1613 7.560470e+00
R_1613_1614 1613 1614 1.423690e+00
R_1614_1615 1614 1615 8.922509e-01
R_1615_1616 1615 1616 8.928771e+00
R_1616_1617 1616 1617 7.313713e+00
R_1617_1618 1617 1618 1.644636e+00
R_1618_1619 1618 1619 6.590503e-01
R_1619_1620 1619 1620 3.395600e+00
R_1620_1621 1620 1621 5.321065e+00
R_1621_1622 1621 1622 9.146359e+00
R_1622_1623 1622 1623 7.467532e+00
R_1623_1624 1623 1624 9.238498e+00
R_1624_1625 1624 1625 4.682161e+00
R_1625_1626 1625 1626 4.189428e+00
R_1626_1627 1626 1627 1.845852e-01
R_1627_1628 1627 1628 4.779598e+00
R_1628_1629 1628 1629 6.366356e+00
R_1629_1630 1629 1630 8.592692e+00
R_1630_1631 1630 1631 1.619231e+00
R_1631_1632 1631 1632 5.698414e+00
R_1632_1633 1632 1633 1.702479e+00
R_1633_1634 1633 1634 9.199167e-01
R_1634_1635 1634 1635 9.369018e+00
R_1635_1636 1635 1636 5.970181e+00
R_1636_1637 1636 1637 2.790784e-01
R_1637_1638 1637 1638 8.072834e+00
R_1638_1639 1638 1639 7.699256e+00
R_1639_1640 1639 1640 9.896343e+00
R_1640_1641 1640 1641 2.067765e+00
R_1641_1642 1641 1642 9.058129e+00
R_1642_1643 1642 1643 3.375129e+00
R_1643_1644 1643 1644 8.776746e+00
R_1644_1645 1644 1645 2.433493e+00
R_1645_1646 1645 1646 9.325884e+00
R_1646_1647 1646 1647 7.801880e-01
R_1647_1648 1647 1648 1.158143e+00
R_1648_1649 1648 1649 2.156997e+00
R_1649_1650 1649 1650 5.926898e+00
R_1650_1651 1650 1651 9.532917e+00
R_1651_1652 1651 1652 4.593866e+00
R_1652_1653 1652 1653 4.882332e+00
R_1653_1654 1653 1654 6.052780e+00
R_1654_1655 1654 1655 3.084169e+00
R_1655_1656 1655 1656 7.418198e+00
R_1656_1657 1656 1657 2.782705e+00
R_1657_1658 1657 1658 5.306173e-01
R_1658_1659 1658 1659 1.360523e+00
R_1659_1660 1659 1660 1.690356e+00
R_1660_1661 1660 1661 9.807547e+00
R_1661_1662 1661 1662 3.594210e+00
R_1662_1663 1662 1663 3.316040e+00
R_1663_1664 1663 1664 4.090162e+00
R_1664_1665 1664 1665 3.346065e+00
R_1665_1666 1665 1666 4.008086e-01
R_1666_1667 1666 1667 8.204846e+00
R_1667_1668 1667 1668 2.014027e+00
R_1668_1669 1668 1669 3.608072e+00
R_1669_1670 1669 1670 2.073328e+00
R_1670_1671 1670 1671 5.050493e+00
R_1671_1672 1671 1672 6.769278e-01
R_1672_1673 1672 1673 9.918361e+00
R_1673_1674 1673 1674 3.356586e+00
R_1674_1675 1674 1675 9.729145e+00
R_1675_1676 1675 1676 5.374120e+00
R_1676_1677 1676 1677 7.656524e+00
R_1677_1678 1677 1678 7.396187e+00
R_1678_1679 1678 1679 4.138025e+00
R_1679_1680 1679 1680 9.381382e+00
R_1680_1681 1680 1681 3.295812e+00
R_1681_1682 1681 1682 8.906785e+00
R_1682_1683 1682 1683 4.777490e+00
R_1683_1684 1683 1684 5.607467e+00
R_1684_1685 1684 1685 2.764037e+00
R_1685_1686 1685 1686 9.569550e+00
R_1686_1687 1686 1687 2.543941e+00
R_1687_1688 1687 1688 8.084031e-02
R_1688_1689 1688 1689 2.914531e+00
R_1689_1690 1689 1690 4.536939e-01
R_1690_1691 1690 1691 3.180363e+00
R_1691_1692 1691 1692 1.476032e+00
R_1692_1693 1692 1693 4.182405e+00
R_1693_1694 1693 1694 8.568960e+00
R_1694_1695 1694 1695 5.922763e+00
R_1695_1696 1695 1696 5.327551e+00
R_1696_1697 1696 1697 9.833132e+00
R_1697_1698 1697 1698 6.171479e+00
R_1698_1699 1698 1699 5.198472e+00
R_1699_1700 1699 1700 4.638735e+00
R_1701_1702 1701 1702 6.278744e+00
R_1702_1703 1702 1703 9.859181e+00
R_1703_1704 1703 1704 4.065401e+00
R_1704_1705 1704 1705 3.557108e+00
R_1705_1706 1705 1706 2.535596e+00
R_1706_1707 1706 1707 5.586931e+00
R_1707_1708 1707 1708 6.554245e+00
R_1708_1709 1708 1709 4.460179e+00
R_1709_1710 1709 1710 8.380230e+00
R_1710_1711 1710 1711 7.463700e+00
R_1711_1712 1711 1712 7.780303e-01
R_1712_1713 1712 1713 8.313599e+00
R_1713_1714 1713 1714 9.465139e+00
R_1714_1715 1714 1715 8.059937e+00
R_1715_1716 1715 1716 4.026944e+00
R_1716_1717 1716 1717 7.117150e+00
R_1717_1718 1717 1718 9.545647e+00
R_1718_1719 1718 1719 1.372943e+00
R_1719_1720 1719 1720 9.728693e-01
R_1720_1721 1720 1721 9.060403e+00
R_1721_1722 1721 1722 7.128844e+00
R_1722_1723 1722 1723 1.066014e+00
R_1723_1724 1723 1724 2.575423e+00
R_1724_1725 1724 1725 2.494627e+00
R_1725_1726 1725 1726 9.530341e-01
R_1726_1727 1726 1727 3.296566e+00
R_1727_1728 1727 1728 3.976712e+00
R_1728_1729 1728 1729 9.260560e+00
R_1729_1730 1729 1730 2.818241e+00
R_1730_1731 1730 1731 5.001848e+00
R_1731_1732 1731 1732 8.341711e+00
R_1732_1733 1732 1733 6.724555e+00
R_1733_1734 1733 1734 4.878314e+00
R_1734_1735 1734 1735 7.487333e+00
R_1735_1736 1735 1736 8.885126e+00
R_1736_1737 1736 1737 5.177378e+00
R_1737_1738 1737 1738 3.683530e+00
R_1738_1739 1738 1739 7.068975e+00
R_1739_1740 1739 1740 7.358444e+00
R_1740_1741 1740 1741 4.970037e+00
R_1741_1742 1741 1742 7.949293e+00
R_1742_1743 1742 1743 4.323535e+00
R_1743_1744 1743 1744 5.384277e+00
R_1744_1745 1744 1745 8.323348e+00
R_1745_1746 1745 1746 8.769591e+00
R_1746_1747 1746 1747 9.529763e+00
R_1747_1748 1747 1748 8.864161e+00
R_1748_1749 1748 1749 9.176638e+00
R_1749_1750 1749 1750 9.147578e+00
R_1750_1751 1750 1751 6.751753e+00
R_1751_1752 1751 1752 2.232125e+00
R_1752_1753 1752 1753 8.062490e+00
R_1753_1754 1753 1754 7.238069e+00
R_1754_1755 1754 1755 1.143229e+00
R_1755_1756 1755 1756 1.919227e+00
R_1756_1757 1756 1757 5.818727e-01
R_1757_1758 1757 1758 3.102954e+00
R_1758_1759 1758 1759 5.803115e+00
R_1759_1760 1759 1760 5.082983e+00
R_1760_1761 1760 1761 1.003087e+00
R_1761_1762 1761 1762 8.110623e+00
R_1762_1763 1762 1763 2.009741e+00
R_1763_1764 1763 1764 8.030719e+00
R_1764_1765 1764 1765 4.628682e+00
R_1765_1766 1765 1766 7.661602e+00
R_1766_1767 1766 1767 4.753067e+00
R_1767_1768 1767 1768 7.543119e+00
R_1768_1769 1768 1769 6.600681e+00
R_1769_1770 1769 1770 3.198778e+00
R_1770_1771 1770 1771 4.174178e+00
R_1771_1772 1771 1772 3.119429e+00
R_1772_1773 1772 1773 6.907201e+00
R_1773_1774 1773 1774 8.699446e+00
R_1774_1775 1774 1775 4.746790e-01
R_1775_1776 1775 1776 3.371602e+00
R_1776_1777 1776 1777 2.336517e+00
R_1777_1778 1777 1778 5.873710e+00
R_1778_1779 1778 1779 5.053890e+00
R_1779_1780 1779 1780 4.197404e+00
R_1780_1781 1780 1781 6.353569e+00
R_1781_1782 1781 1782 3.663035e+00
R_1782_1783 1782 1783 8.100119e+00
R_1783_1784 1783 1784 2.828799e+00
R_1784_1785 1784 1785 2.503170e+00
R_1785_1786 1785 1786 7.537883e-01
R_1786_1787 1786 1787 1.421375e+00
R_1787_1788 1787 1788 4.526729e+00
R_1788_1789 1788 1789 8.801271e+00
R_1789_1790 1789 1790 1.272520e+00
R_1790_1791 1790 1791 9.515827e+00
R_1791_1792 1791 1792 4.841291e+00
R_1792_1793 1792 1793 3.369428e+00
R_1793_1794 1793 1794 3.976511e-01
R_1794_1795 1794 1795 4.350829e+00
R_1795_1796 1795 1796 2.434392e+00
R_1796_1797 1796 1797 9.380428e+00
R_1797_1798 1797 1798 8.580107e+00
R_1798_1799 1798 1799 4.270767e+00
R_1799_1800 1799 1800 8.903193e+00
R_1801_1802 1801 1802 4.186195e+00
R_1802_1803 1802 1803 5.597087e+00
R_1803_1804 1803 1804 1.928845e-01
R_1804_1805 1804 1805 6.702228e+00
R_1805_1806 1805 1806 3.018182e+00
R_1806_1807 1806 1807 1.010727e-01
R_1807_1808 1807 1808 2.593727e+00
R_1808_1809 1808 1809 5.699102e+00
R_1809_1810 1809 1810 2.413509e+00
R_1810_1811 1810 1811 3.190280e+00
R_1811_1812 1811 1812 9.263106e+00
R_1812_1813 1812 1813 9.540876e+00
R_1813_1814 1813 1814 9.913305e-01
R_1814_1815 1814 1815 3.449746e+00
R_1815_1816 1815 1816 4.009441e+00
R_1816_1817 1816 1817 5.790859e+00
R_1817_1818 1817 1818 9.705591e+00
R_1818_1819 1818 1819 4.653298e-01
R_1819_1820 1819 1820 9.963286e+00
R_1820_1821 1820 1821 1.683862e-01
R_1821_1822 1821 1822 5.700744e+00
R_1822_1823 1822 1823 6.326990e+00
R_1823_1824 1823 1824 5.826515e+00
R_1824_1825 1824 1825 4.285535e+00
R_1825_1826 1825 1826 8.844935e-01
R_1826_1827 1826 1827 3.302597e+00
R_1827_1828 1827 1828 8.745320e+00
R_1828_1829 1828 1829 6.927426e-01
R_1829_1830 1829 1830 1.646683e+00
R_1830_1831 1830 1831 3.075976e+00
R_1831_1832 1831 1832 6.918014e+00
R_1832_1833 1832 1833 3.447775e+00
R_1833_1834 1833 1834 1.718219e+00
R_1834_1835 1834 1835 8.989921e-01
R_1835_1836 1835 1836 1.758259e+00
R_1836_1837 1836 1837 2.857562e+00
R_1837_1838 1837 1838 5.182915e+00
R_1838_1839 1838 1839 1.940723e+00
R_1839_1840 1839 1840 1.043553e+00
R_1840_1841 1840 1841 9.986481e-01
R_1841_1842 1841 1842 9.047965e+00
R_1842_1843 1842 1843 5.032167e+00
R_1843_1844 1843 1844 1.671937e+00
R_1844_1845 1844 1845 2.346081e+00
R_1845_1846 1845 1846 3.893950e+00
R_1846_1847 1846 1847 6.898105e+00
R_1847_1848 1847 1848 2.607455e+00
R_1848_1849 1848 1849 7.303478e+00
R_1849_1850 1849 1850 4.624962e+00
R_1850_1851 1850 1851 9.240932e+00
R_1851_1852 1851 1852 6.313090e+00
R_1852_1853 1852 1853 9.118067e+00
R_1853_1854 1853 1854 6.323487e+00
R_1854_1855 1854 1855 4.433373e+00
R_1855_1856 1855 1856 8.058055e-01
R_1856_1857 1856 1857 7.476305e+00
R_1857_1858 1857 1858 2.010784e+00
R_1858_1859 1858 1859 6.507721e+00
R_1859_1860 1859 1860 5.707637e+00
R_1860_1861 1860 1861 7.143471e-01
R_1861_1862 1861 1862 4.292656e+00
R_1862_1863 1862 1863 9.242568e+00
R_1863_1864 1863 1864 2.337242e+00
R_1864_1865 1864 1865 7.298586e+00
R_1865_1866 1865 1866 8.678159e+00
R_1866_1867 1866 1867 8.734716e+00
R_1867_1868 1867 1868 4.827393e+00
R_1868_1869 1868 1869 2.012916e-01
R_1869_1870 1869 1870 9.568883e+00
R_1870_1871 1870 1871 6.874768e+00
R_1871_1872 1871 1872 1.046877e+00
R_1872_1873 1872 1873 3.208452e+00
R_1873_1874 1873 1874 7.395764e+00
R_1874_1875 1874 1875 5.903719e+00
R_1875_1876 1875 1876 7.018188e+00
R_1876_1877 1876 1877 1.380158e+00
R_1877_1878 1877 1878 2.388670e+00
R_1878_1879 1878 1879 8.597206e-01
R_1879_1880 1879 1880 1.663808e+00
R_1880_1881 1880 1881 5.992994e+00
R_1881_1882 1881 1882 2.587869e+00
R_1882_1883 1882 1883 7.565550e-01
R_1883_1884 1883 1884 5.925282e+00
R_1884_1885 1884 1885 5.257090e+00
R_1885_1886 1885 1886 6.883010e+00
R_1886_1887 1886 1887 9.104273e+00
R_1887_1888 1887 1888 8.928666e+00
R_1888_1889 1888 1889 6.737062e+00
R_1889_1890 1889 1890 5.478246e+00
R_1890_1891 1890 1891 9.278973e-01
R_1891_1892 1891 1892 4.856801e+00
R_1892_1893 1892 1893 3.513395e+00
R_1893_1894 1893 1894 1.211674e+00
R_1894_1895 1894 1895 7.300466e-01
R_1895_1896 1895 1896 7.168414e+00
R_1896_1897 1896 1897 5.043996e-01
R_1897_1898 1897 1898 2.369158e+00
R_1898_1899 1898 1899 4.706061e+00
R_1899_1900 1899 1900 9.090852e+00
R_1901_1902 1901 1902 1.719670e+00
R_1902_1903 1902 1903 3.996024e+00
R_1903_1904 1903 1904 4.170292e+00
R_1904_1905 1904 1905 2.481715e+00
R_1905_1906 1905 1906 3.919277e+00
R_1906_1907 1906 1907 5.803616e+00
R_1907_1908 1907 1908 8.675816e+00
R_1908_1909 1908 1909 5.644143e+00
R_1909_1910 1909 1910 2.408212e+00
R_1910_1911 1910 1911 5.926615e+00
R_1911_1912 1911 1912 5.307086e+00
R_1912_1913 1912 1913 5.975020e+00
R_1913_1914 1913 1914 8.780666e+00
R_1914_1915 1914 1915 9.891849e+00
R_1915_1916 1915 1916 8.688292e+00
R_1916_1917 1916 1917 2.788639e+00
R_1917_1918 1917 1918 6.701510e-01
R_1918_1919 1918 1919 7.002825e+00
R_1919_1920 1919 1920 8.280687e+00
R_1920_1921 1920 1921 9.883060e+00
R_1921_1922 1921 1922 9.196630e+00
R_1922_1923 1922 1923 3.090298e+00
R_1923_1924 1923 1924 8.669334e+00
R_1924_1925 1924 1925 8.299536e+00
R_1925_1926 1925 1926 8.489423e+00
R_1926_1927 1926 1927 6.259741e+00
R_1927_1928 1927 1928 4.474139e+00
R_1928_1929 1928 1929 5.540959e+00
R_1929_1930 1929 1930 8.740515e+00
R_1930_1931 1930 1931 3.124044e-01
R_1931_1932 1931 1932 3.015959e+00
R_1932_1933 1932 1933 1.169258e+00
R_1933_1934 1933 1934 2.748852e+00
R_1934_1935 1934 1935 6.661497e+00
R_1935_1936 1935 1936 1.662058e+00
R_1936_1937 1936 1937 8.735143e+00
R_1937_1938 1937 1938 6.879159e+00
R_1938_1939 1938 1939 7.589805e+00
R_1939_1940 1939 1940 8.502626e+00
R_1940_1941 1940 1941 8.249761e+00
R_1941_1942 1941 1942 8.517206e+00
R_1942_1943 1942 1943 3.339754e+00
R_1943_1944 1943 1944 2.005282e+00
R_1944_1945 1944 1945 7.975723e+00
R_1945_1946 1945 1946 9.887648e+00
R_1946_1947 1946 1947 2.690434e+00
R_1947_1948 1947 1948 7.525642e+00
R_1948_1949 1948 1949 4.712492e+00
R_1949_1950 1949 1950 8.989776e+00
R_1950_1951 1950 1951 7.670413e+00
R_1951_1952 1951 1952 2.882383e+00
R_1952_1953 1952 1953 4.280996e+00
R_1953_1954 1953 1954 3.644732e+00
R_1954_1955 1954 1955 1.227456e-01
R_1955_1956 1955 1956 1.408853e+00
R_1956_1957 1956 1957 7.604056e+00
R_1957_1958 1957 1958 6.668777e+00
R_1958_1959 1958 1959 2.167991e+00
R_1959_1960 1959 1960 2.304347e+00
R_1960_1961 1960 1961 5.980203e+00
R_1961_1962 1961 1962 2.411368e+00
R_1962_1963 1962 1963 5.671197e-01
R_1963_1964 1963 1964 6.874022e-02
R_1964_1965 1964 1965 4.411437e-01
R_1965_1966 1965 1966 1.217777e+00
R_1966_1967 1966 1967 7.793176e+00
R_1967_1968 1967 1968 9.471190e+00
R_1968_1969 1968 1969 1.114455e-01
R_1969_1970 1969 1970 1.178802e-01
R_1970_1971 1970 1971 9.418461e+00
R_1971_1972 1971 1972 1.673078e+00
R_1972_1973 1972 1973 5.836844e+00
R_1973_1974 1973 1974 3.585190e+00
R_1974_1975 1974 1975 3.571624e+00
R_1975_1976 1975 1976 8.424865e+00
R_1976_1977 1976 1977 5.490748e+00
R_1977_1978 1977 1978 1.688487e-01
R_1978_1979 1978 1979 4.899936e+00
R_1979_1980 1979 1980 6.050886e+00
R_1980_1981 1980 1981 5.908019e-01
R_1981_1982 1981 1982 8.757584e+00
R_1982_1983 1982 1983 1.410839e+00
R_1983_1984 1983 1984 8.138046e+00
R_1984_1985 1984 1985 2.912554e+00
R_1985_1986 1985 1986 2.831525e+00
R_1986_1987 1986 1987 1.594451e+00
R_1987_1988 1987 1988 7.716490e+00
R_1988_1989 1988 1989 9.787315e+00
R_1989_1990 1989 1990 6.591005e+00
R_1990_1991 1990 1991 2.880489e+00
R_1991_1992 1991 1992 9.707724e+00
R_1992_1993 1992 1993 2.538178e+00
R_1993_1994 1993 1994 9.606560e+00
R_1994_1995 1994 1995 1.774796e+00
R_1995_1996 1995 1996 5.992059e+00
R_1996_1997 1996 1997 9.590918e+00
R_1997_1998 1997 1998 2.449227e+00
R_1998_1999 1998 1999 2.758969e+00
R_1999_2000 1999 2000 2.392480e+00
R_2001_2002 2001 2002 5.302798e+00
R_2002_2003 2002 2003 7.575446e-01
R_2003_2004 2003 2004 3.547788e+00
R_2004_2005 2004 2005 9.677489e+00
R_2005_2006 2005 2006 4.073891e+00
R_2006_2007 2006 2007 1.585706e+00
R_2007_2008 2007 2008 3.285556e+00
R_2008_2009 2008 2009 9.598400e+00
R_2009_2010 2009 2010 7.191642e+00
R_2010_2011 2010 2011 6.650988e+00
R_2011_2012 2011 2012 6.917014e-01
R_2012_2013 2012 2013 3.311714e+00
R_2013_2014 2013 2014 2.633404e+00
R_2014_2015 2014 2015 5.379111e+00
R_2015_2016 2015 2016 4.589467e+00
R_2016_2017 2016 2017 9.039846e+00
R_2017_2018 2017 2018 6.256143e+00
R_2018_2019 2018 2019 9.909453e+00
R_2019_2020 2019 2020 1.885133e-01
R_2020_2021 2020 2021 5.803222e+00
R_2021_2022 2021 2022 1.346383e+00
R_2022_2023 2022 2023 3.675315e+00
R_2023_2024 2023 2024 2.136732e+00
R_2024_2025 2024 2025 2.995548e+00
R_2025_2026 2025 2026 2.375600e+00
R_2026_2027 2026 2027 2.411610e+00
R_2027_2028 2027 2028 7.740095e+00
R_2028_2029 2028 2029 4.698408e+00
R_2029_2030 2029 2030 3.783301e+00
R_2030_2031 2030 2031 3.659046e+00
R_2031_2032 2031 2032 8.625611e+00
R_2032_2033 2032 2033 1.362290e+00
R_2033_2034 2033 2034 2.016285e+00
R_2034_2035 2034 2035 9.889486e+00
R_2035_2036 2035 2036 8.428332e+00
R_2036_2037 2036 2037 1.532338e+00
R_2037_2038 2037 2038 3.108912e+00
R_2038_2039 2038 2039 3.254348e+00
R_2039_2040 2039 2040 6.630005e+00
R_2040_2041 2040 2041 6.289070e+00
R_2041_2042 2041 2042 2.507469e+00
R_2042_2043 2042 2043 1.135181e+00
R_2043_2044 2043 2044 4.515731e+00
R_2044_2045 2044 2045 6.650668e+00
R_2045_2046 2045 2046 4.326395e+00
R_2046_2047 2046 2047 2.628730e-01
R_2047_2048 2047 2048 7.236981e+00
R_2048_2049 2048 2049 1.994658e+00
R_2049_2050 2049 2050 8.949275e+00
R_2050_2051 2050 2051 2.763838e+00
R_2051_2052 2051 2052 7.625761e-01
R_2052_2053 2052 2053 1.935176e+00
R_2053_2054 2053 2054 4.672289e+00
R_2054_2055 2054 2055 8.528647e-01
R_2055_2056 2055 2056 3.175661e-01
R_2056_2057 2056 2057 6.584523e+00
R_2057_2058 2057 2058 1.866061e+00
R_2058_2059 2058 2059 9.271644e+00
R_2059_2060 2059 2060 3.273936e+00
R_2060_2061 2060 2061 4.771989e+00
R_2061_2062 2061 2062 9.596294e+00
R_2062_2063 2062 2063 4.152896e+00
R_2063_2064 2063 2064 8.248781e+00
R_2064_2065 2064 2065 6.506071e+00
R_2065_2066 2065 2066 5.459776e+00
R_2066_2067 2066 2067 9.483090e+00
R_2067_2068 2067 2068 7.705974e+00
R_2068_2069 2068 2069 4.884208e+00
R_2069_2070 2069 2070 3.786937e+00
R_2070_2071 2070 2071 5.475055e+00
R_2071_2072 2071 2072 4.640968e+00
R_2072_2073 2072 2073 4.963302e+00
R_2073_2074 2073 2074 6.793993e+00
R_2074_2075 2074 2075 6.901302e+00
R_2075_2076 2075 2076 7.877274e+00
R_2076_2077 2076 2077 8.645748e-01
R_2077_2078 2077 2078 6.805970e+00
R_2078_2079 2078 2079 2.372424e-01
R_2079_2080 2079 2080 6.029563e+00
R_2080_2081 2080 2081 4.494991e-01
R_2081_2082 2081 2082 4.426787e+00
R_2082_2083 2082 2083 7.066161e+00
R_2083_2084 2083 2084 7.424533e+00
R_2084_2085 2084 2085 1.727620e+00
R_2085_2086 2085 2086 3.221316e+00
R_2086_2087 2086 2087 6.358865e+00
R_2087_2088 2087 2088 9.948465e+00
R_2088_2089 2088 2089 9.285377e+00
R_2089_2090 2089 2090 7.601501e+00
R_2090_2091 2090 2091 1.338369e+00
R_2091_2092 2091 2092 7.357082e+00
R_2092_2093 2092 2093 6.552636e+00
R_2093_2094 2093 2094 8.417557e+00
R_2094_2095 2094 2095 8.679898e+00
R_2095_2096 2095 2096 5.563858e+00
R_2096_2097 2096 2097 7.468774e+00
R_2097_2098 2097 2098 7.720409e+00
R_2098_2099 2098 2099 5.220570e+00
R_2099_2100 2099 2100 6.788754e+00
R_2101_2102 2101 2102 9.793142e-01
R_2102_2103 2102 2103 9.966968e+00
R_2103_2104 2103 2104 7.617222e+00
R_2104_2105 2104 2105 7.865888e+00
R_2105_2106 2105 2106 5.645374e+00
R_2106_2107 2106 2107 7.941938e+00
R_2107_2108 2107 2108 9.934923e+00
R_2108_2109 2108 2109 1.004668e+00
R_2109_2110 2109 2110 9.493385e+00
R_2110_2111 2110 2111 5.547424e+00
R_2111_2112 2111 2112 7.560482e+00
R_2112_2113 2112 2113 9.374845e+00
R_2113_2114 2113 2114 8.274266e+00
R_2114_2115 2114 2115 7.213827e+00
R_2115_2116 2115 2116 1.735516e+00
R_2116_2117 2116 2117 6.559660e+00
R_2117_2118 2117 2118 2.831589e+00
R_2118_2119 2118 2119 1.200838e+00
R_2119_2120 2119 2120 8.499935e+00
R_2120_2121 2120 2121 3.304517e+00
R_2121_2122 2121 2122 8.412060e+00
R_2122_2123 2122 2123 4.973153e+00
R_2123_2124 2123 2124 6.365238e+00
R_2124_2125 2124 2125 9.610867e+00
R_2125_2126 2125 2126 2.732345e+00
R_2126_2127 2126 2127 5.253399e+00
R_2127_2128 2127 2128 6.800602e+00
R_2128_2129 2128 2129 1.814382e+00
R_2129_2130 2129 2130 9.374442e+00
R_2130_2131 2130 2131 1.143006e+00
R_2131_2132 2131 2132 6.091376e+00
R_2132_2133 2132 2133 2.672296e-01
R_2133_2134 2133 2134 7.862358e+00
R_2134_2135 2134 2135 5.367935e+00
R_2135_2136 2135 2136 1.709160e+00
R_2136_2137 2136 2137 7.049896e+00
R_2137_2138 2137 2138 5.822804e+00
R_2138_2139 2138 2139 2.409983e-01
R_2139_2140 2139 2140 1.927094e+00
R_2140_2141 2140 2141 3.509339e+00
R_2141_2142 2141 2142 5.271169e+00
R_2142_2143 2142 2143 3.244291e+00
R_2143_2144 2143 2144 8.185896e+00
R_2144_2145 2144 2145 2.015119e+00
R_2145_2146 2145 2146 6.776907e+00
R_2146_2147 2146 2147 5.132779e+00
R_2147_2148 2147 2148 1.418721e-01
R_2148_2149 2148 2149 3.809758e+00
R_2149_2150 2149 2150 6.041209e+00
R_2150_2151 2150 2151 9.930882e+00
R_2151_2152 2151 2152 7.245550e+00
R_2152_2153 2152 2153 3.494627e+00
R_2153_2154 2153 2154 3.078624e+00
R_2154_2155 2154 2155 2.798280e+00
R_2155_2156 2155 2156 4.384829e+00
R_2156_2157 2156 2157 3.875836e+00
R_2157_2158 2157 2158 7.720735e+00
R_2158_2159 2158 2159 5.718331e+00
R_2159_2160 2159 2160 2.565721e+00
R_2160_2161 2160 2161 9.625624e+00
R_2161_2162 2161 2162 1.998059e+00
R_2162_2163 2162 2163 5.732627e-01
R_2163_2164 2163 2164 6.067556e+00
R_2164_2165 2164 2165 8.879319e-01
R_2165_2166 2165 2166 1.183789e+00
R_2166_2167 2166 2167 5.760525e+00
R_2167_2168 2167 2168 1.329963e+00
R_2168_2169 2168 2169 8.904908e+00
R_2169_2170 2169 2170 2.334055e+00
R_2170_2171 2170 2171 2.359782e+00
R_2171_2172 2171 2172 1.294135e+00
R_2172_2173 2172 2173 4.905505e+00
R_2173_2174 2173 2174 3.027050e+00
R_2174_2175 2174 2175 3.764139e+00
R_2175_2176 2175 2176 6.376875e-01
R_2176_2177 2176 2177 4.862525e+00
R_2177_2178 2177 2178 3.012364e+00
R_2178_2179 2178 2179 1.138820e+00
R_2179_2180 2179 2180 7.207604e+00
R_2180_2181 2180 2181 6.639594e+00
R_2181_2182 2181 2182 9.485103e-01
R_2182_2183 2182 2183 6.092592e+00
R_2183_2184 2183 2184 1.867720e+00
R_2184_2185 2184 2185 6.899928e+00
R_2185_2186 2185 2186 4.170439e-02
R_2186_2187 2186 2187 3.650826e+00
R_2187_2188 2187 2188 2.173373e-01
R_2188_2189 2188 2189 5.713792e+00
R_2189_2190 2189 2190 1.741518e+00
R_2190_2191 2190 2191 3.444384e+00
R_2191_2192 2191 2192 4.865174e+00
R_2192_2193 2192 2193 3.669245e-01
R_2193_2194 2193 2194 9.837166e+00
R_2194_2195 2194 2195 2.039184e+00
R_2195_2196 2195 2196 6.401323e+00
R_2196_2197 2196 2197 2.405088e-01
R_2197_2198 2197 2198 7.654807e+00
R_2198_2199 2198 2199 4.090954e+00
R_2199_2200 2199 2200 4.968662e+00
R_2201_2202 2201 2202 5.848727e+00
R_2202_2203 2202 2203 1.041973e+00
R_2203_2204 2203 2204 6.971495e-01
R_2204_2205 2204 2205 9.281020e+00
R_2205_2206 2205 2206 8.262459e+00
R_2206_2207 2206 2207 5.438140e+00
R_2207_2208 2207 2208 7.495836e+00
R_2208_2209 2208 2209 9.936423e+00
R_2209_2210 2209 2210 8.881609e+00
R_2210_2211 2210 2211 4.504763e+00
R_2211_2212 2211 2212 5.024926e-01
R_2212_2213 2212 2213 8.507852e+00
R_2213_2214 2213 2214 6.869184e+00
R_2214_2215 2214 2215 4.505981e+00
R_2215_2216 2215 2216 5.673269e-01
R_2216_2217 2216 2217 3.940982e+00
R_2217_2218 2217 2218 6.639565e-01
R_2218_2219 2218 2219 8.784590e+00
R_2219_2220 2219 2220 1.302709e+00
R_2220_2221 2220 2221 3.920905e+00
R_2221_2222 2221 2222 5.455708e+00
R_2222_2223 2222 2223 8.628846e+00
R_2223_2224 2223 2224 3.496811e+00
R_2224_2225 2224 2225 1.602768e+00
R_2225_2226 2225 2226 6.406853e+00
R_2226_2227 2226 2227 6.527951e+00
R_2227_2228 2227 2228 5.774719e+00
R_2228_2229 2228 2229 9.033540e-01
R_2229_2230 2229 2230 9.137832e+00
R_2230_2231 2230 2231 8.795541e+00
R_2231_2232 2231 2232 1.162503e+00
R_2232_2233 2232 2233 2.570599e+00
R_2233_2234 2233 2234 8.784967e+00
R_2234_2235 2234 2235 5.838377e+00
R_2235_2236 2235 2236 3.490218e+00
R_2236_2237 2236 2237 5.676332e+00
R_2237_2238 2237 2238 7.679048e+00
R_2238_2239 2238 2239 6.133614e+00
R_2239_2240 2239 2240 4.866630e+00
R_2240_2241 2240 2241 9.686439e+00
R_2241_2242 2241 2242 4.682884e+00
R_2242_2243 2242 2243 2.990082e+00
R_2243_2244 2243 2244 7.651386e+00
R_2244_2245 2244 2245 2.568430e+00
R_2245_2246 2245 2246 5.096288e+00
R_2246_2247 2246 2247 8.909204e+00
R_2247_2248 2247 2248 6.729557e+00
R_2248_2249 2248 2249 9.355522e+00
R_2249_2250 2249 2250 3.001262e+00
R_2250_2251 2250 2251 2.682655e+00
R_2251_2252 2251 2252 8.190322e-01
R_2252_2253 2252 2253 1.640283e+00
R_2253_2254 2253 2254 1.147004e+00
R_2254_2255 2254 2255 5.165519e+00
R_2255_2256 2255 2256 2.799809e+00
R_2256_2257 2256 2257 8.962903e+00
R_2257_2258 2257 2258 1.343438e+00
R_2258_2259 2258 2259 8.191087e+00
R_2259_2260 2259 2260 1.087204e+00
R_2260_2261 2260 2261 8.518884e+00
R_2261_2262 2261 2262 5.354967e+00
R_2262_2263 2262 2263 9.559270e+00
R_2263_2264 2263 2264 8.552707e+00
R_2264_2265 2264 2265 7.972255e+00
R_2265_2266 2265 2266 7.009893e+00
R_2266_2267 2266 2267 1.280876e+00
R_2267_2268 2267 2268 5.458488e-01
R_2268_2269 2268 2269 4.815976e+00
R_2269_2270 2269 2270 4.082064e+00
R_2270_2271 2270 2271 6.781622e+00
R_2271_2272 2271 2272 6.908746e+00
R_2272_2273 2272 2273 5.665114e+00
R_2273_2274 2273 2274 9.328769e+00
R_2274_2275 2274 2275 8.517351e-01
R_2275_2276 2275 2276 7.931173e+00
R_2276_2277 2276 2277 9.681486e+00
R_2277_2278 2277 2278 9.522788e+00
R_2278_2279 2278 2279 9.350978e+00
R_2279_2280 2279 2280 3.347956e+00
R_2280_2281 2280 2281 4.218760e+00
R_2281_2282 2281 2282 8.378298e+00
R_2282_2283 2282 2283 5.480661e+00
R_2283_2284 2283 2284 7.073017e+00
R_2284_2285 2284 2285 3.385094e+00
R_2285_2286 2285 2286 5.666220e+00
R_2286_2287 2286 2287 2.043647e+00
R_2287_2288 2287 2288 9.061990e+00
R_2288_2289 2288 2289 7.740748e+00
R_2289_2290 2289 2290 9.039751e+00
R_2290_2291 2290 2291 2.279917e+00
R_2291_2292 2291 2292 8.810783e+00
R_2292_2293 2292 2293 8.885293e-01
R_2293_2294 2293 2294 5.074886e+00
R_2294_2295 2294 2295 6.956233e+00
R_2295_2296 2295 2296 4.655232e+00
R_2296_2297 2296 2297 1.075353e+00
R_2297_2298 2297 2298 1.365407e+00
R_2298_2299 2298 2299 3.069945e+00
R_2299_2300 2299 2300 9.574989e+00
R_2301_2302 2301 2302 2.351582e+00
R_2302_2303 2302 2303 7.594860e+00
R_2303_2304 2303 2304 7.276063e+00
R_2304_2305 2304 2305 8.448396e+00
R_2305_2306 2305 2306 4.378519e+00
R_2306_2307 2306 2307 3.415896e-01
R_2307_2308 2307 2308 3.081743e+00
R_2308_2309 2308 2309 1.320493e+00
R_2309_2310 2309 2310 2.930085e+00
R_2310_2311 2310 2311 7.000756e+00
R_2311_2312 2311 2312 2.056214e+00
R_2312_2313 2312 2313 8.444358e+00
R_2313_2314 2313 2314 6.595173e+00
R_2314_2315 2314 2315 9.885416e+00
R_2315_2316 2315 2316 2.312994e+00
R_2316_2317 2316 2317 2.259356e+00
R_2317_2318 2317 2318 2.651072e+00
R_2318_2319 2318 2319 9.749384e+00
R_2319_2320 2319 2320 2.736949e+00
R_2320_2321 2320 2321 2.449964e+00
R_2321_2322 2321 2322 8.963131e+00
R_2322_2323 2322 2323 9.192389e+00
R_2323_2324 2323 2324 5.435251e+00
R_2324_2325 2324 2325 2.662834e+00
R_2325_2326 2325 2326 7.497052e+00
R_2326_2327 2326 2327 2.640673e+00
R_2327_2328 2327 2328 8.175120e+00
R_2328_2329 2328 2329 3.950888e-01
R_2329_2330 2329 2330 1.664990e+00
R_2330_2331 2330 2331 4.564089e-01
R_2331_2332 2331 2332 4.561496e+00
R_2332_2333 2332 2333 5.774338e+00
R_2333_2334 2333 2334 8.306771e+00
R_2334_2335 2334 2335 6.667835e+00
R_2335_2336 2335 2336 8.353497e-01
R_2336_2337 2336 2337 4.966970e+00
R_2337_2338 2337 2338 4.885121e+00
R_2338_2339 2338 2339 2.209512e+00
R_2339_2340 2339 2340 2.434485e+00
R_2340_2341 2340 2341 7.294818e+00
R_2341_2342 2341 2342 5.887606e-01
R_2342_2343 2342 2343 9.659015e+00
R_2343_2344 2343 2344 2.059915e+00
R_2344_2345 2344 2345 8.738821e+00
R_2345_2346 2345 2346 6.096003e+00
R_2346_2347 2346 2347 3.426441e+00
R_2347_2348 2347 2348 7.983875e+00
R_2348_2349 2348 2349 5.641068e-01
R_2349_2350 2349 2350 2.908512e+00
R_2350_2351 2350 2351 6.717182e+00
R_2351_2352 2351 2352 1.915638e+00
R_2352_2353 2352 2353 5.228487e+00
R_2353_2354 2353 2354 3.718211e-01
R_2354_2355 2354 2355 2.413645e+00
R_2355_2356 2355 2356 9.623218e+00
R_2356_2357 2356 2357 4.155451e+00
R_2357_2358 2357 2358 7.558230e+00
R_2358_2359 2358 2359 9.484199e+00
R_2359_2360 2359 2360 5.637343e+00
R_2360_2361 2360 2361 2.279298e+00
R_2361_2362 2361 2362 2.131044e+00
R_2362_2363 2362 2363 5.641328e+00
R_2363_2364 2363 2364 5.054501e+00
R_2364_2365 2364 2365 8.539276e+00
R_2365_2366 2365 2366 5.732327e+00
R_2366_2367 2366 2367 6.526490e+00
R_2367_2368 2367 2368 8.953865e+00
R_2368_2369 2368 2369 2.244250e+00
R_2369_2370 2369 2370 8.042773e-01
R_2370_2371 2370 2371 9.790327e+00
R_2371_2372 2371 2372 2.596079e+00
R_2372_2373 2372 2373 1.347989e+00
R_2373_2374 2373 2374 7.167637e+00
R_2374_2375 2374 2375 4.426591e+00
R_2375_2376 2375 2376 4.298978e+00
R_2376_2377 2376 2377 9.466919e+00
R_2377_2378 2377 2378 2.964195e+00
R_2378_2379 2378 2379 7.725838e+00
R_2379_2380 2379 2380 4.351179e+00
R_2380_2381 2380 2381 6.242332e+00
R_2381_2382 2381 2382 6.135562e+00
R_2382_2383 2382 2383 4.122020e+00
R_2383_2384 2383 2384 2.609451e+00
R_2384_2385 2384 2385 6.297022e+00
R_2385_2386 2385 2386 1.216914e+00
R_2386_2387 2386 2387 3.886730e+00
R_2387_2388 2387 2388 6.087189e+00
R_2388_2389 2388 2389 4.812321e-01
R_2389_2390 2389 2390 1.358977e+00
R_2390_2391 2390 2391 6.629164e+00
R_2391_2392 2391 2392 4.562326e+00
R_2392_2393 2392 2393 3.665958e+00
R_2393_2394 2393 2394 4.700547e+00
R_2394_2395 2394 2395 8.482742e+00
R_2395_2396 2395 2396 8.844922e+00
R_2396_2397 2396 2397 9.823396e+00
R_2397_2398 2397 2398 6.875675e+00
R_2398_2399 2398 2399 6.322094e+00
R_2399_2400 2399 2400 9.665152e+00
R_2401_2402 2401 2402 7.120636e+00
R_2402_2403 2402 2403 7.232521e+00
R_2403_2404 2403 2404 3.966352e+00
R_2404_2405 2404 2405 3.220602e+00
R_2405_2406 2405 2406 1.491070e-01
R_2406_2407 2406 2407 9.028598e-01
R_2407_2408 2407 2408 3.853867e+00
R_2408_2409 2408 2409 8.929706e+00
R_2409_2410 2409 2410 7.893458e+00
R_2410_2411 2410 2411 1.458344e+00
R_2411_2412 2411 2412 7.998096e+00
R_2412_2413 2412 2413 6.707811e+00
R_2413_2414 2413 2414 7.904939e+00
R_2414_2415 2414 2415 7.530895e+00
R_2415_2416 2415 2416 9.282943e+00
R_2416_2417 2416 2417 8.172142e+00
R_2417_2418 2417 2418 8.861281e-01
R_2418_2419 2418 2419 7.073819e+00
R_2419_2420 2419 2420 2.951400e+00
R_2420_2421 2420 2421 7.206247e+00
R_2421_2422 2421 2422 1.678635e+00
R_2422_2423 2422 2423 7.507855e+00
R_2423_2424 2423 2424 5.486531e+00
R_2424_2425 2424 2425 8.194796e+00
R_2425_2426 2425 2426 7.472768e-01
R_2426_2427 2426 2427 1.435016e+00
R_2427_2428 2427 2428 7.349800e+00
R_2428_2429 2428 2429 1.893163e+00
R_2429_2430 2429 2430 8.333200e+00
R_2430_2431 2430 2431 6.300330e+00
R_2431_2432 2431 2432 3.131865e-01
R_2432_2433 2432 2433 5.532377e+00
R_2433_2434 2433 2434 6.154780e+00
R_2434_2435 2434 2435 1.363264e+00
R_2435_2436 2435 2436 2.136004e+00
R_2436_2437 2436 2437 1.866855e+00
R_2437_2438 2437 2438 5.155596e-01
R_2438_2439 2438 2439 4.664723e+00
R_2439_2440 2439 2440 1.866692e+00
R_2440_2441 2440 2441 9.269021e+00
R_2441_2442 2441 2442 5.417758e+00
R_2442_2443 2442 2443 2.773970e+00
R_2443_2444 2443 2444 1.365889e+00
R_2444_2445 2444 2445 3.810359e+00
R_2445_2446 2445 2446 3.573747e+00
R_2446_2447 2446 2447 6.137635e+00
R_2447_2448 2447 2448 6.049391e+00
R_2448_2449 2448 2449 5.240522e+00
R_2449_2450 2449 2450 2.755959e-01
R_2450_2451 2450 2451 8.182617e+00
R_2451_2452 2451 2452 5.404953e+00
R_2452_2453 2452 2453 3.815922e+00
R_2453_2454 2453 2454 7.515364e+00
R_2454_2455 2454 2455 1.296228e+00
R_2455_2456 2455 2456 2.481773e+00
R_2456_2457 2456 2457 9.052272e+00
R_2457_2458 2457 2458 7.289615e+00
R_2458_2459 2458 2459 1.290872e-01
R_2459_2460 2459 2460 8.055818e+00
R_2460_2461 2460 2461 4.985351e+00
R_2461_2462 2461 2462 1.571480e-01
R_2462_2463 2462 2463 9.912543e+00
R_2463_2464 2463 2464 3.318326e+00
R_2464_2465 2464 2465 3.525980e+00
R_2465_2466 2465 2466 3.591091e+00
R_2466_2467 2466 2467 8.014267e+00
R_2467_2468 2467 2468 4.197875e-01
R_2468_2469 2468 2469 5.131965e+00
R_2469_2470 2469 2470 4.903076e+00
R_2470_2471 2470 2471 8.718256e+00
R_2471_2472 2471 2472 4.952123e+00
R_2472_2473 2472 2473 3.392927e+00
R_2473_2474 2473 2474 5.721595e+00
R_2474_2475 2474 2475 5.088281e+00
R_2475_2476 2475 2476 7.835973e+00
R_2476_2477 2476 2477 4.751923e+00
R_2477_2478 2477 2478 4.740204e+00
R_2478_2479 2478 2479 9.312091e+00
R_2479_2480 2479 2480 4.398400e+00
R_2480_2481 2480 2481 9.754547e+00
R_2481_2482 2481 2482 5.086359e+00
R_2482_2483 2482 2483 7.272884e+00
R_2483_2484 2483 2484 1.343643e+00
R_2484_2485 2484 2485 1.552918e+00
R_2485_2486 2485 2486 3.743870e+00
R_2486_2487 2486 2487 4.122032e+00
R_2487_2488 2487 2488 6.791588e+00
R_2488_2489 2488 2489 1.048848e+00
R_2489_2490 2489 2490 6.437752e+00
R_2490_2491 2490 2491 6.105027e-01
R_2491_2492 2491 2492 8.045983e+00
R_2492_2493 2492 2493 4.539937e+00
R_2493_2494 2493 2494 9.967719e+00
R_2494_2495 2494 2495 1.831625e+00
R_2495_2496 2495 2496 5.767151e+00
R_2496_2497 2496 2497 8.449481e+00
R_2497_2498 2497 2498 8.969131e+00
R_2498_2499 2498 2499 5.006979e+00
R_2499_2500 2499 2500 6.266905e-02
R_2501_2502 2501 2502 6.980831e+00
R_2502_2503 2502 2503 8.287173e+00
R_2503_2504 2503 2504 9.018544e+00
R_2504_2505 2504 2505 8.872745e+00
R_2505_2506 2505 2506 5.428870e+00
R_2506_2507 2506 2507 5.419481e+00
R_2507_2508 2507 2508 7.370087e+00
R_2508_2509 2508 2509 3.342725e+00
R_2509_2510 2509 2510 8.352001e+00
R_2510_2511 2510 2511 6.912824e-01
R_2511_2512 2511 2512 6.551878e+00
R_2512_2513 2512 2513 7.792023e+00
R_2513_2514 2513 2514 7.580644e+00
R_2514_2515 2514 2515 9.876610e+00
R_2515_2516 2515 2516 8.773001e+00
R_2516_2517 2516 2517 4.004151e+00
R_2517_2518 2517 2518 1.451481e+00
R_2518_2519 2518 2519 8.077861e+00
R_2519_2520 2519 2520 8.125143e+00
R_2520_2521 2520 2521 8.335662e+00
R_2521_2522 2521 2522 7.089073e+00
R_2522_2523 2522 2523 3.806843e+00
R_2523_2524 2523 2524 9.236753e+00
R_2524_2525 2524 2525 8.584185e+00
R_2525_2526 2525 2526 8.162582e+00
R_2526_2527 2526 2527 8.792479e+00
R_2527_2528 2527 2528 5.268942e+00
R_2528_2529 2528 2529 2.959674e+00
R_2529_2530 2529 2530 9.828957e+00
R_2530_2531 2530 2531 4.564222e+00
R_2531_2532 2531 2532 7.823250e+00
R_2532_2533 2532 2533 4.701091e+00
R_2533_2534 2533 2534 7.150647e+00
R_2534_2535 2534 2535 5.661496e+00
R_2535_2536 2535 2536 2.909090e+00
R_2536_2537 2536 2537 7.481556e+00
R_2537_2538 2537 2538 5.395069e+00
R_2538_2539 2538 2539 3.340927e+00
R_2539_2540 2539 2540 7.105200e-01
R_2540_2541 2540 2541 4.560726e+00
R_2541_2542 2541 2542 2.270998e+00
R_2542_2543 2542 2543 3.537326e+00
R_2543_2544 2543 2544 5.963259e+00
R_2544_2545 2544 2545 8.029805e+00
R_2545_2546 2545 2546 8.021275e+00
R_2546_2547 2546 2547 2.542861e+00
R_2547_2548 2547 2548 7.673590e+00
R_2548_2549 2548 2549 4.186672e+00
R_2549_2550 2549 2550 5.691041e+00
R_2550_2551 2550 2551 2.726397e+00
R_2551_2552 2551 2552 2.007964e-01
R_2552_2553 2552 2553 4.102868e+00
R_2553_2554 2553 2554 3.602727e+00
R_2554_2555 2554 2555 4.991647e+00
R_2555_2556 2555 2556 9.630955e+00
R_2556_2557 2556 2557 1.331204e+00
R_2557_2558 2557 2558 6.398232e+00
R_2558_2559 2558 2559 6.096989e+00
R_2559_2560 2559 2560 7.079414e+00
R_2560_2561 2560 2561 4.640986e+00
R_2561_2562 2561 2562 8.721543e+00
R_2562_2563 2562 2563 6.859304e+00
R_2563_2564 2563 2564 5.405307e+00
R_2564_2565 2564 2565 9.771602e+00
R_2565_2566 2565 2566 9.924215e+00
R_2566_2567 2566 2567 9.886293e+00
R_2567_2568 2567 2568 4.735740e+00
R_2568_2569 2568 2569 8.593928e-01
R_2569_2570 2569 2570 5.742713e+00
R_2570_2571 2570 2571 3.611768e+00
R_2571_2572 2571 2572 3.971926e+00
R_2572_2573 2572 2573 4.542757e+00
R_2573_2574 2573 2574 8.113874e+00
R_2574_2575 2574 2575 5.754966e-01
R_2575_2576 2575 2576 2.019578e+00
R_2576_2577 2576 2577 4.408186e-03
R_2577_2578 2577 2578 5.872469e-01
R_2578_2579 2578 2579 8.138394e+00
R_2579_2580 2579 2580 2.086141e+00
R_2580_2581 2580 2581 8.321422e+00
R_2581_2582 2581 2582 8.451463e+00
R_2582_2583 2582 2583 8.421051e+00
R_2583_2584 2583 2584 3.969005e+00
R_2584_2585 2584 2585 6.575116e+00
R_2585_2586 2585 2586 8.304654e+00
R_2586_2587 2586 2587 1.247775e+00
R_2587_2588 2587 2588 5.590926e+00
R_2588_2589 2588 2589 5.438476e+00
R_2589_2590 2589 2590 5.207156e+00
R_2590_2591 2590 2591 5.727231e+00
R_2591_2592 2591 2592 6.392158e+00
R_2592_2593 2592 2593 5.695186e+00
R_2593_2594 2593 2594 3.897568e+00
R_2594_2595 2594 2595 8.182695e+00
R_2595_2596 2595 2596 1.651340e+00
R_2596_2597 2596 2597 3.335186e+00
R_2597_2598 2597 2598 1.525456e+00
R_2598_2599 2598 2599 4.465679e+00
R_2599_2600 2599 2600 7.453821e+00
R_2601_2602 2601 2602 5.954777e+00
R_2602_2603 2602 2603 9.606291e+00
R_2603_2604 2603 2604 7.906515e-01
R_2604_2605 2604 2605 4.806425e+00
R_2605_2606 2605 2606 2.328542e-01
R_2606_2607 2606 2607 8.847562e+00
R_2607_2608 2607 2608 7.940969e+00
R_2608_2609 2608 2609 3.860356e+00
R_2609_2610 2609 2610 3.983911e+00
R_2610_2611 2610 2611 2.781517e+00
R_2611_2612 2611 2612 2.391074e-01
R_2612_2613 2612 2613 2.425743e+00
R_2613_2614 2613 2614 9.164314e+00
R_2614_2615 2614 2615 3.256292e-02
R_2615_2616 2615 2616 8.028982e+00
R_2616_2617 2616 2617 9.317236e+00
R_2617_2618 2617 2618 2.205313e+00
R_2618_2619 2618 2619 8.483287e-01
R_2619_2620 2619 2620 9.006482e+00
R_2620_2621 2620 2621 4.271042e+00
R_2621_2622 2621 2622 1.453838e+00
R_2622_2623 2622 2623 6.539969e+00
R_2623_2624 2623 2624 3.662604e+00
R_2624_2625 2624 2625 3.115011e+00
R_2625_2626 2625 2626 6.260486e+00
R_2626_2627 2626 2627 2.522004e+00
R_2627_2628 2627 2628 7.025326e+00
R_2628_2629 2628 2629 8.841235e+00
R_2629_2630 2629 2630 9.913304e+00
R_2630_2631 2630 2631 6.358032e+00
R_2631_2632 2631 2632 2.319918e+00
R_2632_2633 2632 2633 1.446040e+00
R_2633_2634 2633 2634 6.610089e+00
R_2634_2635 2634 2635 7.126142e+00
R_2635_2636 2635 2636 1.726874e+00
R_2636_2637 2636 2637 1.968368e+00
R_2637_2638 2637 2638 7.443871e+00
R_2638_2639 2638 2639 8.047416e+00
R_2639_2640 2639 2640 7.313949e+00
R_2640_2641 2640 2641 1.015996e+00
R_2641_2642 2641 2642 6.558797e+00
R_2642_2643 2642 2643 5.820658e+00
R_2643_2644 2643 2644 1.835350e+00
R_2644_2645 2644 2645 9.841771e-01
R_2645_2646 2645 2646 8.631977e+00
R_2646_2647 2646 2647 5.062964e+00
R_2647_2648 2647 2648 5.171711e+00
R_2648_2649 2648 2649 2.867062e+00
R_2649_2650 2649 2650 8.824142e+00
R_2650_2651 2650 2651 4.987251e+00
R_2651_2652 2651 2652 8.177619e+00
R_2652_2653 2652 2653 9.681216e+00
R_2653_2654 2653 2654 2.613404e+00
R_2654_2655 2654 2655 3.215889e+00
R_2655_2656 2655 2656 6.682553e+00
R_2656_2657 2656 2657 8.246228e+00
R_2657_2658 2657 2658 2.918067e+00
R_2658_2659 2658 2659 6.539379e+00
R_2659_2660 2659 2660 1.567135e+00
R_2660_2661 2660 2661 5.891486e+00
R_2661_2662 2661 2662 6.896516e+00
R_2662_2663 2662 2663 7.431625e-01
R_2663_2664 2663 2664 9.062973e+00
R_2664_2665 2664 2665 7.263492e+00
R_2665_2666 2665 2666 2.489931e+00
R_2666_2667 2666 2667 5.743187e+00
R_2667_2668 2667 2668 9.741058e+00
R_2668_2669 2668 2669 5.692412e-01
R_2669_2670 2669 2670 3.204272e+00
R_2670_2671 2670 2671 5.152877e+00
R_2671_2672 2671 2672 4.799731e+00
R_2672_2673 2672 2673 8.523499e+00
R_2673_2674 2673 2674 9.504405e+00
R_2674_2675 2674 2675 4.913587e+00
R_2675_2676 2675 2676 7.343045e+00
R_2676_2677 2676 2677 8.914232e+00
R_2677_2678 2677 2678 1.812573e+00
R_2678_2679 2678 2679 6.846109e+00
R_2679_2680 2679 2680 4.150426e+00
R_2680_2681 2680 2681 4.039975e+00
R_2681_2682 2681 2682 7.583840e+00
R_2682_2683 2682 2683 2.965602e+00
R_2683_2684 2683 2684 6.625184e+00
R_2684_2685 2684 2685 6.479210e+00
R_2685_2686 2685 2686 3.632793e+00
R_2686_2687 2686 2687 8.196889e+00
R_2687_2688 2687 2688 5.618676e-01
R_2688_2689 2688 2689 6.534585e+00
R_2689_2690 2689 2690 4.156308e+00
R_2690_2691 2690 2691 8.974498e+00
R_2691_2692 2691 2692 9.339067e+00
R_2692_2693 2692 2693 6.723764e+00
R_2693_2694 2693 2694 8.056217e+00
R_2694_2695 2694 2695 4.460647e+00
R_2695_2696 2695 2696 1.014814e+00
R_2696_2697 2696 2697 8.035737e+00
R_2697_2698 2697 2698 8.071638e+00
R_2698_2699 2698 2699 7.475037e+00
R_2699_2700 2699 2700 3.411832e+00
R_2701_2702 2701 2702 1.901280e+00
R_2702_2703 2702 2703 8.031543e+00
R_2703_2704 2703 2704 2.952865e+00
R_2704_2705 2704 2705 5.471133e+00
R_2705_2706 2705 2706 8.264030e+00
R_2706_2707 2706 2707 7.207237e+00
R_2707_2708 2707 2708 6.399181e+00
R_2708_2709 2708 2709 4.064851e+00
R_2709_2710 2709 2710 4.494867e+00
R_2710_2711 2710 2711 4.483096e+00
R_2711_2712 2711 2712 5.089453e+00
R_2712_2713 2712 2713 1.372193e+00
R_2713_2714 2713 2714 3.586372e+00
R_2714_2715 2714 2715 6.506477e+00
R_2715_2716 2715 2716 5.273551e+00
R_2716_2717 2716 2717 4.715300e+00
R_2717_2718 2717 2718 9.616934e+00
R_2718_2719 2718 2719 8.138523e+00
R_2719_2720 2719 2720 5.651860e-01
R_2720_2721 2720 2721 7.017303e+00
R_2721_2722 2721 2722 4.062931e+00
R_2722_2723 2722 2723 4.925605e+00
R_2723_2724 2723 2724 7.581394e+00
R_2724_2725 2724 2725 3.107465e+00
R_2725_2726 2725 2726 1.632544e-01
R_2726_2727 2726 2727 1.777156e-01
R_2727_2728 2727 2728 4.996792e+00
R_2728_2729 2728 2729 3.950565e+00
R_2729_2730 2729 2730 8.986272e+00
R_2730_2731 2730 2731 2.699873e+00
R_2731_2732 2731 2732 4.829109e+00
R_2732_2733 2732 2733 1.640705e+00
R_2733_2734 2733 2734 7.047046e+00
R_2734_2735 2734 2735 3.144831e+00
R_2735_2736 2735 2736 3.281919e+00
R_2736_2737 2736 2737 1.819614e+00
R_2737_2738 2737 2738 7.422462e+00
R_2738_2739 2738 2739 4.030825e+00
R_2739_2740 2739 2740 2.297153e+00
R_2740_2741 2740 2741 6.374959e+00
R_2741_2742 2741 2742 5.354534e+00
R_2742_2743 2742 2743 3.352913e+00
R_2743_2744 2743 2744 3.963281e+00
R_2744_2745 2744 2745 9.411438e+00
R_2745_2746 2745 2746 7.877645e+00
R_2746_2747 2746 2747 9.290736e+00
R_2747_2748 2747 2748 6.274024e+00
R_2748_2749 2748 2749 3.228548e+00
R_2749_2750 2749 2750 8.724024e+00
R_2750_2751 2750 2751 6.888730e+00
R_2751_2752 2751 2752 1.186453e+00
R_2752_2753 2752 2753 5.440198e+00
R_2753_2754 2753 2754 5.762314e+00
R_2754_2755 2754 2755 7.778191e+00
R_2755_2756 2755 2756 1.005889e+00
R_2756_2757 2756 2757 8.634417e+00
R_2757_2758 2757 2758 3.441296e+00
R_2758_2759 2758 2759 4.879453e+00
R_2759_2760 2759 2760 1.119949e+00
R_2760_2761 2760 2761 9.336797e+00
R_2761_2762 2761 2762 5.374217e+00
R_2762_2763 2762 2763 8.364271e+00
R_2763_2764 2763 2764 4.659052e+00
R_2764_2765 2764 2765 1.075522e+00
R_2765_2766 2765 2766 6.295335e+00
R_2766_2767 2766 2767 3.757307e+00
R_2767_2768 2767 2768 4.458394e+00
R_2768_2769 2768 2769 3.026196e+00
R_2769_2770 2769 2770 9.714566e+00
R_2770_2771 2770 2771 5.434965e+00
R_2771_2772 2771 2772 1.360980e+00
R_2772_2773 2772 2773 6.288996e+00
R_2773_2774 2773 2774 9.613937e+00
R_2774_2775 2774 2775 8.068493e+00
R_2775_2776 2775 2776 5.671894e+00
R_2776_2777 2776 2777 8.146866e-01
R_2777_2778 2777 2778 4.415584e+00
R_2778_2779 2778 2779 9.687074e+00
R_2779_2780 2779 2780 2.600397e+00
R_2780_2781 2780 2781 3.942984e+00
R_2781_2782 2781 2782 7.015482e+00
R_2782_2783 2782 2783 1.669315e+00
R_2783_2784 2783 2784 7.020433e+00
R_2784_2785 2784 2785 2.393201e+00
R_2785_2786 2785 2786 6.845975e-01
R_2786_2787 2786 2787 8.483972e+00
R_2787_2788 2787 2788 9.745614e+00
R_2788_2789 2788 2789 6.115320e+00
R_2789_2790 2789 2790 5.248607e+00
R_2790_2791 2790 2791 2.661622e+00
R_2791_2792 2791 2792 8.823973e+00
R_2792_2793 2792 2793 3.254489e+00
R_2793_2794 2793 2794 5.460117e+00
R_2794_2795 2794 2795 3.294369e+00
R_2795_2796 2795 2796 7.686518e-01
R_2796_2797 2796 2797 7.024423e+00
R_2797_2798 2797 2798 1.730543e+00
R_2798_2799 2798 2799 9.762134e-02
R_2799_2800 2799 2800 7.616305e+00
R_2801_2802 2801 2802 1.245873e+00
R_2802_2803 2802 2803 2.801438e+00
R_2803_2804 2803 2804 5.661133e+00
R_2804_2805 2804 2805 3.733666e-01
R_2805_2806 2805 2806 2.597139e+00
R_2806_2807 2806 2807 7.002391e+00
R_2807_2808 2807 2808 3.613394e+00
R_2808_2809 2808 2809 2.433386e+00
R_2809_2810 2809 2810 7.074486e-01
R_2810_2811 2810 2811 7.422950e+00
R_2811_2812 2811 2812 8.941094e-01
R_2812_2813 2812 2813 1.022000e+00
R_2813_2814 2813 2814 4.920664e+00
R_2814_2815 2814 2815 9.088955e+00
R_2815_2816 2815 2816 8.210901e+00
R_2816_2817 2816 2817 5.729880e+00
R_2817_2818 2817 2818 5.247833e+00
R_2818_2819 2818 2819 2.358724e-01
R_2819_2820 2819 2820 6.012659e+00
R_2820_2821 2820 2821 5.263281e+00
R_2821_2822 2821 2822 2.796067e+00
R_2822_2823 2822 2823 7.500309e+00
R_2823_2824 2823 2824 8.412260e+00
R_2824_2825 2824 2825 7.680884e+00
R_2825_2826 2825 2826 9.043981e+00
R_2826_2827 2826 2827 4.798265e+00
R_2827_2828 2827 2828 5.935740e-01
R_2828_2829 2828 2829 2.149747e+00
R_2829_2830 2829 2830 4.418763e+00
R_2830_2831 2830 2831 3.582657e+00
R_2831_2832 2831 2832 8.408456e+00
R_2832_2833 2832 2833 4.647013e+00
R_2833_2834 2833 2834 6.382641e+00
R_2834_2835 2834 2835 5.084849e-01
R_2835_2836 2835 2836 7.429069e+00
R_2836_2837 2836 2837 6.663058e+00
R_2837_2838 2837 2838 3.767084e+00
R_2838_2839 2838 2839 3.336298e+00
R_2839_2840 2839 2840 5.801431e+00
R_2840_2841 2840 2841 2.232142e+00
R_2841_2842 2841 2842 3.951685e+00
R_2842_2843 2842 2843 1.291535e+00
R_2843_2844 2843 2844 6.667644e+00
R_2844_2845 2844 2845 5.627583e-01
R_2845_2846 2845 2846 1.815931e+00
R_2846_2847 2846 2847 6.500364e+00
R_2847_2848 2847 2848 4.934991e+00
R_2848_2849 2848 2849 2.259230e-01
R_2849_2850 2849 2850 4.219410e-01
R_2850_2851 2850 2851 8.293094e-01
R_2851_2852 2851 2852 8.877795e+00
R_2852_2853 2852 2853 3.029597e+00
R_2853_2854 2853 2854 3.158984e+00
R_2854_2855 2854 2855 5.967802e+00
R_2855_2856 2855 2856 9.678525e+00
R_2856_2857 2856 2857 1.632051e+00
R_2857_2858 2857 2858 9.937000e+00
R_2858_2859 2858 2859 8.781391e+00
R_2859_2860 2859 2860 8.177186e+00
R_2860_2861 2860 2861 7.481743e+00
R_2861_2862 2861 2862 2.129170e+00
R_2862_2863 2862 2863 2.629477e+00
R_2863_2864 2863 2864 1.437848e+00
R_2864_2865 2864 2865 2.254437e-01
R_2865_2866 2865 2866 3.370511e+00
R_2866_2867 2866 2867 9.066352e+00
R_2867_2868 2867 2868 2.978960e+00
R_2868_2869 2868 2869 2.655558e+00
R_2869_2870 2869 2870 4.626455e+00
R_2870_2871 2870 2871 5.926607e+00
R_2871_2872 2871 2872 9.958944e+00
R_2872_2873 2872 2873 2.574827e+00
R_2873_2874 2873 2874 8.385140e+00
R_2874_2875 2874 2875 2.826003e+00
R_2875_2876 2875 2876 1.634613e+00
R_2876_2877 2876 2877 1.448560e+00
R_2877_2878 2877 2878 5.250000e+00
R_2878_2879 2878 2879 2.289523e+00
R_2879_2880 2879 2880 5.310755e+00
R_2880_2881 2880 2881 9.311667e+00
R_2881_2882 2881 2882 7.832014e+00
R_2882_2883 2882 2883 5.817308e+00
R_2883_2884 2883 2884 7.305288e+00
R_2884_2885 2884 2885 5.516458e+00
R_2885_2886 2885 2886 5.074493e+00
R_2886_2887 2886 2887 6.027598e+00
R_2887_2888 2887 2888 1.357463e+00
R_2888_2889 2888 2889 8.369526e-01
R_2889_2890 2889 2890 7.267590e+00
R_2890_2891 2890 2891 7.716348e+00
R_2891_2892 2891 2892 1.032111e+00
R_2892_2893 2892 2893 1.099001e+00
R_2893_2894 2893 2894 1.969848e+00
R_2894_2895 2894 2895 6.923814e+00
R_2895_2896 2895 2896 6.903233e+00
R_2896_2897 2896 2897 2.076511e+00
R_2897_2898 2897 2898 8.402188e+00
R_2898_2899 2898 2899 8.197206e+00
R_2899_2900 2899 2900 7.442724e+00
R_2901_2902 2901 2902 5.401949e+00
R_2902_2903 2902 2903 4.329469e+00
R_2903_2904 2903 2904 6.398517e+00
R_2904_2905 2904 2905 9.821264e+00
R_2905_2906 2905 2906 2.627931e+00
R_2906_2907 2906 2907 8.627265e+00
R_2907_2908 2907 2908 3.130383e+00
R_2908_2909 2908 2909 3.805873e+00
R_2909_2910 2909 2910 8.667884e+00
R_2910_2911 2910 2911 5.204392e+00
R_2911_2912 2911 2912 9.182396e+00
R_2912_2913 2912 2913 1.492044e+00
R_2913_2914 2913 2914 3.343278e+00
R_2914_2915 2914 2915 3.797251e+00
R_2915_2916 2915 2916 9.472676e+00
R_2916_2917 2916 2917 2.680873e+00
R_2917_2918 2917 2918 3.519439e+00
R_2918_2919 2918 2919 4.711194e+00
R_2919_2920 2919 2920 8.103234e+00
R_2920_2921 2920 2921 8.864043e+00
R_2921_2922 2921 2922 2.678666e+00
R_2922_2923 2922 2923 9.554611e+00
R_2923_2924 2923 2924 8.320476e+00
R_2924_2925 2924 2925 7.894548e+00
R_2925_2926 2925 2926 7.934596e+00
R_2926_2927 2926 2927 2.623845e+00
R_2927_2928 2927 2928 5.797550e-01
R_2928_2929 2928 2929 3.709001e+00
R_2929_2930 2929 2930 7.052398e+00
R_2930_2931 2930 2931 5.638546e+00
R_2931_2932 2931 2932 7.531201e+00
R_2932_2933 2932 2933 8.448682e+00
R_2933_2934 2933 2934 6.484198e+00
R_2934_2935 2934 2935 8.922339e-01
R_2935_2936 2935 2936 5.948163e+00
R_2936_2937 2936 2937 5.663988e+00
R_2937_2938 2937 2938 6.824255e+00
R_2938_2939 2938 2939 3.634525e+00
R_2939_2940 2939 2940 8.304635e+00
R_2940_2941 2940 2941 1.754402e+00
R_2941_2942 2941 2942 1.238731e+00
R_2942_2943 2942 2943 1.829205e+00
R_2943_2944 2943 2944 1.899676e+00
R_2944_2945 2944 2945 1.278969e+00
R_2945_2946 2945 2946 3.821304e+00
R_2946_2947 2946 2947 2.878134e+00
R_2947_2948 2947 2948 9.188092e+00
R_2948_2949 2948 2949 1.538537e+00
R_2949_2950 2949 2950 2.523260e+00
R_2950_2951 2950 2951 1.954617e-01
R_2951_2952 2951 2952 4.396751e-01
R_2952_2953 2952 2953 5.827131e-01
R_2953_2954 2953 2954 4.460464e+00
R_2954_2955 2954 2955 5.863567e+00
R_2955_2956 2955 2956 3.892828e+00
R_2956_2957 2956 2957 9.569186e+00
R_2957_2958 2957 2958 2.273391e+00
R_2958_2959 2958 2959 6.526845e+00
R_2959_2960 2959 2960 5.546920e+00
R_2960_2961 2960 2961 4.599767e+00
R_2961_2962 2961 2962 4.303283e+00
R_2962_2963 2962 2963 4.700156e+00
R_2963_2964 2963 2964 4.361444e+00
R_2964_2965 2964 2965 9.666179e-01
R_2965_2966 2965 2966 4.379076e+00
R_2966_2967 2966 2967 2.211374e+00
R_2967_2968 2967 2968 6.382413e+00
R_2968_2969 2968 2969 5.428850e+00
R_2969_2970 2969 2970 7.249510e+00
R_2970_2971 2970 2971 4.915321e-02
R_2971_2972 2971 2972 3.991583e+00
R_2972_2973 2972 2973 8.636755e+00
R_2973_2974 2973 2974 9.104553e-01
R_2974_2975 2974 2975 3.944651e+00
R_2975_2976 2975 2976 2.914401e+00
R_2976_2977 2976 2977 4.515395e+00
R_2977_2978 2977 2978 2.890155e+00
R_2978_2979 2978 2979 9.784333e+00
R_2979_2980 2979 2980 8.780261e+00
R_2980_2981 2980 2981 4.756742e+00
R_2981_2982 2981 2982 5.811870e-01
R_2982_2983 2982 2983 5.889877e-01
R_2983_2984 2983 2984 8.385835e+00
R_2984_2985 2984 2985 4.266664e+00
R_2985_2986 2985 2986 2.750422e+00
R_2986_2987 2986 2987 1.118096e+00
R_2987_2988 2987 2988 9.885902e+00
R_2988_2989 2988 2989 4.797227e+00
R_2989_2990 2989 2990 4.619203e-01
R_2990_2991 2990 2991 5.072282e+00
R_2991_2992 2991 2992 9.778531e+00
R_2992_2993 2992 2993 4.305659e+00
R_2993_2994 2993 2994 2.442772e+00
R_2994_2995 2994 2995 8.708621e+00
R_2995_2996 2995 2996 1.909096e+00
R_2996_2997 2996 2997 4.496884e+00
R_2997_2998 2997 2998 2.162792e+00
R_2998_2999 2998 2999 4.936367e+00
R_2999_3000 2999 3000 7.934340e+00
R_3001_3002 3001 3002 5.691305e+00
R_3002_3003 3002 3003 1.334827e+00
R_3003_3004 3003 3004 3.262595e+00
R_3004_3005 3004 3005 6.856304e-01
R_3005_3006 3005 3006 9.930482e+00
R_3006_3007 3006 3007 9.334003e+00
R_3007_3008 3007 3008 1.799946e+00
R_3008_3009 3008 3009 6.474400e+00
R_3009_3010 3009 3010 3.078785e+00
R_3010_3011 3010 3011 6.843095e+00
R_3011_3012 3011 3012 8.576123e+00
R_3012_3013 3012 3013 1.030849e+00
R_3013_3014 3013 3014 9.574861e+00
R_3014_3015 3014 3015 5.107517e+00
R_3015_3016 3015 3016 3.728112e+00
R_3016_3017 3016 3017 3.570895e-01
R_3017_3018 3017 3018 2.478299e+00
R_3018_3019 3018 3019 7.335231e+00
R_3019_3020 3019 3020 6.580480e+00
R_3020_3021 3020 3021 4.603320e+00
R_3021_3022 3021 3022 2.704672e+00
R_3022_3023 3022 3023 3.153420e+00
R_3023_3024 3023 3024 7.647862e+00
R_3024_3025 3024 3025 5.586681e+00
R_3025_3026 3025 3026 8.295495e+00
R_3026_3027 3026 3027 2.105731e+00
R_3027_3028 3027 3028 1.377958e+00
R_3028_3029 3028 3029 7.184894e+00
R_3029_3030 3029 3030 4.626459e+00
R_3030_3031 3030 3031 9.504230e+00
R_3031_3032 3031 3032 9.832866e+00
R_3032_3033 3032 3033 4.383021e+00
R_3033_3034 3033 3034 8.752627e+00
R_3034_3035 3034 3035 3.275377e+00
R_3035_3036 3035 3036 5.417325e-01
R_3036_3037 3036 3037 1.576702e+00
R_3037_3038 3037 3038 5.453864e+00
R_3038_3039 3038 3039 3.875333e+00
R_3039_3040 3039 3040 6.122263e+00
R_3040_3041 3040 3041 9.683432e+00
R_3041_3042 3041 3042 6.959263e+00
R_3042_3043 3042 3043 8.655934e+00
R_3043_3044 3043 3044 6.094279e+00
R_3044_3045 3044 3045 8.471612e+00
R_3045_3046 3045 3046 6.270891e+00
R_3046_3047 3046 3047 7.021849e-01
R_3047_3048 3047 3048 5.154920e+00
R_3048_3049 3048 3049 8.987521e+00
R_3049_3050 3049 3050 2.204923e+00
R_3050_3051 3050 3051 4.989527e+00
R_3051_3052 3051 3052 5.068366e+00
R_3052_3053 3052 3053 1.879818e+00
R_3053_3054 3053 3054 5.266321e-01
R_3054_3055 3054 3055 4.174316e+00
R_3055_3056 3055 3056 2.824214e+00
R_3056_3057 3056 3057 6.060311e+00
R_3057_3058 3057 3058 3.565919e+00
R_3058_3059 3058 3059 9.683338e-01
R_3059_3060 3059 3060 4.289085e+00
R_3060_3061 3060 3061 4.114648e+00
R_3061_3062 3061 3062 3.615050e+00
R_3062_3063 3062 3063 9.335393e+00
R_3063_3064 3063 3064 7.411664e+00
R_3064_3065 3064 3065 1.520331e+00
R_3065_3066 3065 3066 8.497122e+00
R_3066_3067 3066 3067 7.204773e+00
R_3067_3068 3067 3068 8.289726e+00
R_3068_3069 3068 3069 2.847267e+00
R_3069_3070 3069 3070 7.875205e+00
R_3070_3071 3070 3071 6.713538e+00
R_3071_3072 3071 3072 4.632784e+00
R_3072_3073 3072 3073 4.462348e-01
R_3073_3074 3073 3074 9.586070e+00
R_3074_3075 3074 3075 6.599686e+00
R_3075_3076 3075 3076 2.489868e+00
R_3076_3077 3076 3077 1.943881e+00
R_3077_3078 3077 3078 4.958813e+00
R_3078_3079 3078 3079 9.912621e+00
R_3079_3080 3079 3080 7.469730e-01
R_3080_3081 3080 3081 8.965564e+00
R_3081_3082 3081 3082 6.489941e+00
R_3082_3083 3082 3083 7.000842e+00
R_3083_3084 3083 3084 5.549529e+00
R_3084_3085 3084 3085 5.018279e+00
R_3085_3086 3085 3086 1.684110e+00
R_3086_3087 3086 3087 5.584751e+00
R_3087_3088 3087 3088 8.094346e+00
R_3088_3089 3088 3089 8.895440e+00
R_3089_3090 3089 3090 5.747630e+00
R_3090_3091 3090 3091 3.720667e+00
R_3091_3092 3091 3092 7.052396e+00
R_3092_3093 3092 3093 3.719474e+00
R_3093_3094 3093 3094 8.705321e+00
R_3094_3095 3094 3095 3.498780e+00
R_3095_3096 3095 3096 1.156206e+00
R_3096_3097 3096 3097 4.879262e+00
R_3097_3098 3097 3098 2.770353e-02
R_3098_3099 3098 3099 4.273379e+00
R_3099_3100 3099 3100 6.635838e+00
R_3101_3102 3101 3102 1.403825e+00
R_3102_3103 3102 3103 3.178799e+00
R_3103_3104 3103 3104 8.218348e+00
R_3104_3105 3104 3105 7.028769e+00
R_3105_3106 3105 3106 6.349881e+00
R_3106_3107 3106 3107 6.353245e+00
R_3107_3108 3107 3108 9.016224e+00
R_3108_3109 3108 3109 7.680322e+00
R_3109_3110 3109 3110 4.774423e+00
R_3110_3111 3110 3111 9.144707e+00
R_3111_3112 3111 3112 4.119095e-02
R_3112_3113 3112 3113 9.387311e+00
R_3113_3114 3113 3114 1.096253e+00
R_3114_3115 3114 3115 8.433699e-01
R_3115_3116 3115 3116 6.280296e+00
R_3116_3117 3116 3117 9.145304e+00
R_3117_3118 3117 3118 7.442244e+00
R_3118_3119 3118 3119 7.996950e+00
R_3119_3120 3119 3120 1.649295e+00
R_3120_3121 3120 3121 4.591027e+00
R_3121_3122 3121 3122 6.792783e+00
R_3122_3123 3122 3123 1.741881e+00
R_3123_3124 3123 3124 6.328000e+00
R_3124_3125 3124 3125 5.049862e+00
R_3125_3126 3125 3126 3.038800e+00
R_3126_3127 3126 3127 6.910837e+00
R_3127_3128 3127 3128 4.526403e+00
R_3128_3129 3128 3129 7.861946e+00
R_3129_3130 3129 3130 7.998783e+00
R_3130_3131 3130 3131 5.737571e-01
R_3131_3132 3131 3132 6.580965e+00
R_3132_3133 3132 3133 1.839918e-01
R_3133_3134 3133 3134 2.855234e+00
R_3134_3135 3134 3135 8.219789e+00
R_3135_3136 3135 3136 9.673299e+00
R_3136_3137 3136 3137 7.409289e+00
R_3137_3138 3137 3138 7.429539e+00
R_3138_3139 3138 3139 9.230067e+00
R_3139_3140 3139 3140 1.407055e-01
R_3140_3141 3140 3141 4.303222e+00
R_3141_3142 3141 3142 8.231096e+00
R_3142_3143 3142 3143 4.791219e+00
R_3143_3144 3143 3144 9.375395e+00
R_3144_3145 3144 3145 6.091202e+00
R_3145_3146 3145 3146 9.968241e+00
R_3146_3147 3146 3147 7.404415e+00
R_3147_3148 3147 3148 7.012360e+00
R_3148_3149 3148 3149 3.607664e-01
R_3149_3150 3149 3150 1.446026e+00
R_3150_3151 3150 3151 5.207246e+00
R_3151_3152 3151 3152 5.273891e+00
R_3152_3153 3152 3153 7.990593e+00
R_3153_3154 3153 3154 1.387916e+00
R_3154_3155 3154 3155 9.544014e-01
R_3155_3156 3155 3156 4.528841e+00
R_3156_3157 3156 3157 3.647237e+00
R_3157_3158 3157 3158 3.160998e+00
R_3158_3159 3158 3159 5.962258e-01
R_3159_3160 3159 3160 2.700789e+00
R_3160_3161 3160 3161 9.158956e+00
R_3161_3162 3161 3162 5.315620e-01
R_3162_3163 3162 3163 7.574783e+00
R_3163_3164 3163 3164 9.522376e-01
R_3164_3165 3164 3165 5.593099e+00
R_3165_3166 3165 3166 9.867112e+00
R_3166_3167 3166 3167 3.528383e+00
R_3167_3168 3167 3168 6.705060e+00
R_3168_3169 3168 3169 2.866739e+00
R_3169_3170 3169 3170 4.080045e+00
R_3170_3171 3170 3171 6.341716e+00
R_3171_3172 3171 3172 6.977974e+00
R_3172_3173 3172 3173 3.239329e+00
R_3173_3174 3173 3174 6.990542e+00
R_3174_3175 3174 3175 9.937665e+00
R_3175_3176 3175 3176 6.283105e+00
R_3176_3177 3176 3177 4.605497e+00
R_3177_3178 3177 3178 7.370133e+00
R_3178_3179 3178 3179 9.597654e+00
R_3179_3180 3179 3180 7.564298e+00
R_3180_3181 3180 3181 4.642980e-01
R_3181_3182 3181 3182 4.150265e+00
R_3182_3183 3182 3183 3.073036e+00
R_3183_3184 3183 3184 1.465241e+00
R_3184_3185 3184 3185 7.252920e+00
R_3185_3186 3185 3186 6.777205e+00
R_3186_3187 3186 3187 6.114439e+00
R_3187_3188 3187 3188 1.923314e+00
R_3188_3189 3188 3189 9.401046e+00
R_3189_3190 3189 3190 1.384410e+00
R_3190_3191 3190 3191 6.114572e+00
R_3191_3192 3191 3192 4.854761e+00
R_3192_3193 3192 3193 6.866755e-01
R_3193_3194 3193 3194 1.843289e-01
R_3194_3195 3194 3195 2.367315e+00
R_3195_3196 3195 3196 9.898129e+00
R_3196_3197 3196 3197 6.877644e+00
R_3197_3198 3197 3198 3.321227e+00
R_3198_3199 3198 3199 4.527249e+00
R_3199_3200 3199 3200 2.270109e+00
R_3201_3202 3201 3202 9.282393e+00
R_3202_3203 3202 3203 2.089754e+00
R_3203_3204 3203 3204 4.386386e+00
R_3204_3205 3204 3205 6.598929e+00
R_3205_3206 3205 3206 2.930716e+00
R_3206_3207 3206 3207 4.031791e+00
R_3207_3208 3207 3208 9.543258e+00
R_3208_3209 3208 3209 4.745730e+00
R_3209_3210 3209 3210 4.766626e+00
R_3210_3211 3210 3211 4.951568e+00
R_3211_3212 3211 3212 2.246844e+00
R_3212_3213 3212 3213 1.625818e-01
R_3213_3214 3213 3214 2.241710e+00
R_3214_3215 3214 3215 8.719131e-01
R_3215_3216 3215 3216 9.103241e-01
R_3216_3217 3216 3217 4.822121e+00
R_3217_3218 3217 3218 1.071988e+00
R_3218_3219 3218 3219 4.117202e+00
R_3219_3220 3219 3220 5.517371e+00
R_3220_3221 3220 3221 6.109473e+00
R_3221_3222 3221 3222 1.931239e+00
R_3222_3223 3222 3223 3.971354e+00
R_3223_3224 3223 3224 7.460753e+00
R_3224_3225 3224 3225 1.442168e+00
R_3225_3226 3225 3226 2.967131e+00
R_3226_3227 3226 3227 3.718155e+00
R_3227_3228 3227 3228 5.944934e+00
R_3228_3229 3228 3229 6.227775e+00
R_3229_3230 3229 3230 6.526051e+00
R_3230_3231 3230 3231 9.707313e+00
R_3231_3232 3231 3232 4.912159e+00
R_3232_3233 3232 3233 6.290092e+00
R_3233_3234 3233 3234 7.010836e+00
R_3234_3235 3234 3235 6.401658e+00
R_3235_3236 3235 3236 2.917234e+00
R_3236_3237 3236 3237 2.361152e+00
R_3237_3238 3237 3238 5.143109e+00
R_3238_3239 3238 3239 9.917569e+00
R_3239_3240 3239 3240 2.566439e+00
R_3240_3241 3240 3241 3.643418e+00
R_3241_3242 3241 3242 5.482199e+00
R_3242_3243 3242 3243 4.892075e+00
R_3243_3244 3243 3244 6.205627e+00
R_3244_3245 3244 3245 7.414560e+00
R_3245_3246 3245 3246 8.572314e+00
R_3246_3247 3246 3247 9.303943e+00
R_3247_3248 3247 3248 1.147744e-01
R_3248_3249 3248 3249 7.786046e-02
R_3249_3250 3249 3250 3.500701e+00
R_3250_3251 3250 3251 3.205094e+00
R_3251_3252 3251 3252 7.686344e+00
R_3252_3253 3252 3253 8.749088e+00
R_3253_3254 3253 3254 8.221426e+00
R_3254_3255 3254 3255 9.898888e-01
R_3255_3256 3255 3256 7.878478e+00
R_3256_3257 3256 3257 8.352686e+00
R_3257_3258 3257 3258 4.656064e+00
R_3258_3259 3258 3259 9.077632e+00
R_3259_3260 3259 3260 6.675255e+00
R_3260_3261 3260 3261 4.332914e+00
R_3261_3262 3261 3262 3.272881e+00
R_3262_3263 3262 3263 9.153716e+00
R_3263_3264 3263 3264 9.353273e+00
R_3264_3265 3264 3265 6.779166e+00
R_3265_3266 3265 3266 5.717136e+00
R_3266_3267 3266 3267 1.089261e+00
R_3267_3268 3267 3268 2.457289e+00
R_3268_3269 3268 3269 6.676213e+00
R_3269_3270 3269 3270 4.256506e+00
R_3270_3271 3270 3271 2.177696e+00
R_3271_3272 3271 3272 6.067810e+00
R_3272_3273 3272 3273 6.790110e+00
R_3273_3274 3273 3274 9.749405e-01
R_3274_3275 3274 3275 3.113733e+00
R_3275_3276 3275 3276 3.692154e+00
R_3276_3277 3276 3277 1.923708e+00
R_3277_3278 3277 3278 1.027688e+00
R_3278_3279 3278 3279 8.487646e+00
R_3279_3280 3279 3280 6.862524e+00
R_3280_3281 3280 3281 6.535488e+00
R_3281_3282 3281 3282 1.929663e+00
R_3282_3283 3282 3283 3.268793e+00
R_3283_3284 3283 3284 3.857645e+00
R_3284_3285 3284 3285 5.598235e+00
R_3285_3286 3285 3286 3.589657e+00
R_3286_3287 3286 3287 1.318303e+00
R_3287_3288 3287 3288 2.690600e-01
R_3288_3289 3288 3289 8.337179e+00
R_3289_3290 3289 3290 1.029177e+00
R_3290_3291 3290 3291 8.636879e+00
R_3291_3292 3291 3292 7.555420e+00
R_3292_3293 3292 3293 4.960969e+00
R_3293_3294 3293 3294 9.312645e+00
R_3294_3295 3294 3295 8.467621e-01
R_3295_3296 3295 3296 3.818963e+00
R_3296_3297 3296 3297 6.629256e+00
R_3297_3298 3297 3298 4.360485e+00
R_3298_3299 3298 3299 6.064314e+00
R_3299_3300 3299 3300 5.961067e+00
R_3301_3302 3301 3302 2.038204e+00
R_3302_3303 3302 3303 4.810605e+00
R_3303_3304 3303 3304 4.393192e+00
R_3304_3305 3304 3305 9.150398e+00
R_3305_3306 3305 3306 1.857810e+00
R_3306_3307 3306 3307 6.753962e+00
R_3307_3308 3307 3308 3.328663e+00
R_3308_3309 3308 3309 9.023970e+00
R_3309_3310 3309 3310 7.387414e+00
R_3310_3311 3310 3311 3.323407e+00
R_3311_3312 3311 3312 3.375635e+00
R_3312_3313 3312 3313 3.832523e+00
R_3313_3314 3313 3314 2.295603e+00
R_3314_3315 3314 3315 3.141772e+00
R_3315_3316 3315 3316 1.824922e+00
R_3316_3317 3316 3317 5.059989e+00
R_3317_3318 3317 3318 3.219944e+00
R_3318_3319 3318 3319 5.390155e+00
R_3319_3320 3319 3320 7.186828e+00
R_3320_3321 3320 3321 7.418961e+00
R_3321_3322 3321 3322 8.747476e+00
R_3322_3323 3322 3323 8.148907e+00
R_3323_3324 3323 3324 6.594958e+00
R_3324_3325 3324 3325 6.483000e+00
R_3325_3326 3325 3326 5.981066e+00
R_3326_3327 3326 3327 2.528021e+00
R_3327_3328 3327 3328 2.368327e+00
R_3328_3329 3328 3329 3.268251e+00
R_3329_3330 3329 3330 3.481965e+00
R_3330_3331 3330 3331 3.079387e+00
R_3331_3332 3331 3332 7.760210e+00
R_3332_3333 3332 3333 6.038921e+00
R_3333_3334 3333 3334 3.234137e+00
R_3334_3335 3334 3335 7.016654e+00
R_3335_3336 3335 3336 4.820827e+00
R_3336_3337 3336 3337 7.065933e+00
R_3337_3338 3337 3338 1.093509e+00
R_3338_3339 3338 3339 5.242877e+00
R_3339_3340 3339 3340 6.435468e+00
R_3340_3341 3340 3341 4.241131e+00
R_3341_3342 3341 3342 6.950425e+00
R_3342_3343 3342 3343 5.264462e+00
R_3343_3344 3343 3344 1.062492e+00
R_3344_3345 3344 3345 7.701715e+00
R_3345_3346 3345 3346 5.159785e+00
R_3346_3347 3346 3347 1.943767e+00
R_3347_3348 3347 3348 5.293371e+00
R_3348_3349 3348 3349 9.482787e+00
R_3349_3350 3349 3350 5.381748e+00
R_3350_3351 3350 3351 1.998578e+00
R_3351_3352 3351 3352 5.343513e+00
R_3352_3353 3352 3353 5.901139e+00
R_3353_3354 3353 3354 7.991538e+00
R_3354_3355 3354 3355 3.505928e+00
R_3355_3356 3355 3356 2.943895e+00
R_3356_3357 3356 3357 5.567924e+00
R_3357_3358 3357 3358 6.368677e-02
R_3358_3359 3358 3359 8.480417e+00
R_3359_3360 3359 3360 5.517068e+00
R_3360_3361 3360 3361 7.059907e+00
R_3361_3362 3361 3362 1.786986e+00
R_3362_3363 3362 3363 9.346659e+00
R_3363_3364 3363 3364 5.645191e+00
R_3364_3365 3364 3365 8.123052e-01
R_3365_3366 3365 3366 8.607959e+00
R_3366_3367 3366 3367 3.463821e+00
R_3367_3368 3367 3368 7.070607e+00
R_3368_3369 3368 3369 4.548303e+00
R_3369_3370 3369 3370 3.466399e+00
R_3370_3371 3370 3371 1.542534e+00
R_3371_3372 3371 3372 7.921817e+00
R_3372_3373 3372 3373 6.911978e-01
R_3373_3374 3373 3374 5.351088e+00
R_3374_3375 3374 3375 6.837303e+00
R_3375_3376 3375 3376 7.785414e+00
R_3376_3377 3376 3377 1.124700e+00
R_3377_3378 3377 3378 1.764555e-01
R_3378_3379 3378 3379 2.681432e+00
R_3379_3380 3379 3380 8.438417e+00
R_3380_3381 3380 3381 2.714865e+00
R_3381_3382 3381 3382 4.976865e+00
R_3382_3383 3382 3383 6.480768e+00
R_3383_3384 3383 3384 3.659226e+00
R_3384_3385 3384 3385 9.378510e+00
R_3385_3386 3385 3386 9.798134e+00
R_3386_3387 3386 3387 2.499848e+00
R_3387_3388 3387 3388 2.967917e+00
R_3388_3389 3388 3389 3.720639e+00
R_3389_3390 3389 3390 5.217302e+00
R_3390_3391 3390 3391 3.549262e+00
R_3391_3392 3391 3392 9.118959e+00
R_3392_3393 3392 3393 6.140256e+00
R_3393_3394 3393 3394 6.777804e+00
R_3394_3395 3394 3395 4.152679e+00
R_3395_3396 3395 3396 6.098877e+00
R_3396_3397 3396 3397 5.331293e+00
R_3397_3398 3397 3398 1.540547e+00
R_3398_3399 3398 3399 6.765654e-01
R_3399_3400 3399 3400 7.368947e+00
R_3401_3402 3401 3402 3.671947e+00
R_3402_3403 3402 3403 6.970459e+00
R_3403_3404 3403 3404 6.126142e+00
R_3404_3405 3404 3405 3.758655e+00
R_3405_3406 3405 3406 7.181768e+00
R_3406_3407 3406 3407 9.144461e+00
R_3407_3408 3407 3408 6.248208e+00
R_3408_3409 3408 3409 2.434849e+00
R_3409_3410 3409 3410 4.024535e+00
R_3410_3411 3410 3411 3.694861e+00
R_3411_3412 3411 3412 4.457148e+00
R_3412_3413 3412 3413 3.529923e+00
R_3413_3414 3413 3414 9.781300e+00
R_3414_3415 3414 3415 2.436144e+00
R_3415_3416 3415 3416 5.895874e+00
R_3416_3417 3416 3417 5.048540e-01
R_3417_3418 3417 3418 4.877139e+00
R_3418_3419 3418 3419 6.260633e+00
R_3419_3420 3419 3420 4.943164e+00
R_3420_3421 3420 3421 2.451798e+00
R_3421_3422 3421 3422 6.353466e-01
R_3422_3423 3422 3423 1.755191e+00
R_3423_3424 3423 3424 6.867256e+00
R_3424_3425 3424 3425 3.710452e+00
R_3425_3426 3425 3426 6.149594e+00
R_3426_3427 3426 3427 9.812297e+00
R_3427_3428 3427 3428 3.047013e+00
R_3428_3429 3428 3429 4.528308e-01
R_3429_3430 3429 3430 3.760178e+00
R_3430_3431 3430 3431 7.443223e+00
R_3431_3432 3431 3432 1.801954e+00
R_3432_3433 3432 3433 6.514147e+00
R_3433_3434 3433 3434 9.957477e+00
R_3434_3435 3434 3435 2.935340e+00
R_3435_3436 3435 3436 6.432594e+00
R_3436_3437 3436 3437 3.921425e+00
R_3437_3438 3437 3438 1.851781e+00
R_3438_3439 3438 3439 7.111100e-01
R_3439_3440 3439 3440 7.027043e+00
R_3440_3441 3440 3441 7.266569e+00
R_3441_3442 3441 3442 6.421380e+00
R_3442_3443 3442 3443 5.182672e+00
R_3443_3444 3443 3444 7.589853e+00
R_3444_3445 3444 3445 9.256846e+00
R_3445_3446 3445 3446 6.732330e+00
R_3446_3447 3446 3447 6.505017e+00
R_3447_3448 3447 3448 2.532401e+00
R_3448_3449 3448 3449 8.932421e+00
R_3449_3450 3449 3450 4.962716e+00
R_3450_3451 3450 3451 9.213897e+00
R_3451_3452 3451 3452 5.093924e+00
R_3452_3453 3452 3453 8.651768e+00
R_3453_3454 3453 3454 9.721223e+00
R_3454_3455 3454 3455 7.223270e+00
R_3455_3456 3455 3456 1.953951e+00
R_3456_3457 3456 3457 8.611894e+00
R_3457_3458 3457 3458 9.483894e+00
R_3458_3459 3458 3459 9.434486e+00
R_3459_3460 3459 3460 6.527024e+00
R_3460_3461 3460 3461 1.987032e+00
R_3461_3462 3461 3462 7.994554e+00
R_3462_3463 3462 3463 6.431984e+00
R_3463_3464 3463 3464 1.805736e+00
R_3464_3465 3464 3465 6.271530e+00
R_3465_3466 3465 3466 6.512325e+00
R_3466_3467 3466 3467 6.139842e+00
R_3467_3468 3467 3468 8.477925e+00
R_3468_3469 3468 3469 7.203345e+00
R_3469_3470 3469 3470 3.465028e+00
R_3470_3471 3470 3471 9.938831e+00
R_3471_3472 3471 3472 4.152830e+00
R_3472_3473 3472 3473 8.043353e-01
R_3473_3474 3473 3474 1.973863e+00
R_3474_3475 3474 3475 1.307687e+00
R_3475_3476 3475 3476 3.512986e-01
R_3476_3477 3476 3477 9.473831e+00
R_3477_3478 3477 3478 8.550011e+00
R_3478_3479 3478 3479 2.125648e+00
R_3479_3480 3479 3480 6.829745e+00
R_3480_3481 3480 3481 1.314456e-01
R_3481_3482 3481 3482 6.649623e+00
R_3482_3483 3482 3483 4.407610e+00
R_3483_3484 3483 3484 7.090954e+00
R_3484_3485 3484 3485 6.670635e+00
R_3485_3486 3485 3486 6.078345e+00
R_3486_3487 3486 3487 6.343019e+00
R_3487_3488 3487 3488 1.059323e+00
R_3488_3489 3488 3489 7.287512e+00
R_3489_3490 3489 3490 3.273840e+00
R_3490_3491 3490 3491 8.915888e+00
R_3491_3492 3491 3492 9.455185e+00
R_3492_3493 3492 3493 1.410201e+00
R_3493_3494 3493 3494 6.384489e+00
R_3494_3495 3494 3495 6.429550e+00
R_3495_3496 3495 3496 3.485647e+00
R_3496_3497 3496 3497 6.587937e-01
R_3497_3498 3497 3498 3.894787e+00
R_3498_3499 3498 3499 3.281833e-02
R_3499_3500 3499 3500 6.748342e+00
R_3501_3502 3501 3502 5.174255e+00
R_3502_3503 3502 3503 7.159881e+00
R_3503_3504 3503 3504 6.549244e+00
R_3504_3505 3504 3505 7.560976e+00
R_3505_3506 3505 3506 8.613156e+00
R_3506_3507 3506 3507 6.098328e+00
R_3507_3508 3507 3508 8.797825e+00
R_3508_3509 3508 3509 3.118771e+00
R_3509_3510 3509 3510 9.477245e+00
R_3510_3511 3510 3511 4.529296e+00
R_3511_3512 3511 3512 9.300877e-02
R_3512_3513 3512 3513 6.396938e+00
R_3513_3514 3513 3514 2.763154e+00
R_3514_3515 3514 3515 2.365777e+00
R_3515_3516 3515 3516 3.851837e+00
R_3516_3517 3516 3517 2.819272e+00
R_3517_3518 3517 3518 3.551800e+00
R_3518_3519 3518 3519 6.383453e+00
R_3519_3520 3519 3520 2.616636e+00
R_3520_3521 3520 3521 4.886082e+00
R_3521_3522 3521 3522 4.104929e+00
R_3522_3523 3522 3523 8.467221e+00
R_3523_3524 3523 3524 6.557951e+00
R_3524_3525 3524 3525 3.154026e+00
R_3525_3526 3525 3526 9.845519e+00
R_3526_3527 3526 3527 8.452763e+00
R_3527_3528 3527 3528 7.363775e+00
R_3528_3529 3528 3529 6.223984e+00
R_3529_3530 3529 3530 9.972202e+00
R_3530_3531 3530 3531 4.664310e+00
R_3531_3532 3531 3532 3.414683e+00
R_3532_3533 3532 3533 7.140100e+00
R_3533_3534 3533 3534 5.040162e+00
R_3534_3535 3534 3535 4.331681e+00
R_3535_3536 3535 3536 8.438287e+00
R_3536_3537 3536 3537 3.294137e+00
R_3537_3538 3537 3538 8.532432e+00
R_3538_3539 3538 3539 8.384061e+00
R_3539_3540 3539 3540 1.957813e+00
R_3540_3541 3540 3541 2.102466e+00
R_3541_3542 3541 3542 6.884831e+00
R_3542_3543 3542 3543 4.997419e+00
R_3543_3544 3543 3544 2.798046e-02
R_3544_3545 3544 3545 7.353970e+00
R_3545_3546 3545 3546 4.784130e+00
R_3546_3547 3546 3547 2.119180e+00
R_3547_3548 3547 3548 6.258154e+00
R_3548_3549 3548 3549 3.618691e+00
R_3549_3550 3549 3550 2.871068e+00
R_3550_3551 3550 3551 8.584231e+00
R_3551_3552 3551 3552 9.993618e+00
R_3552_3553 3552 3553 9.004849e+00
R_3553_3554 3553 3554 5.081574e+00
R_3554_3555 3554 3555 6.886497e+00
R_3555_3556 3555 3556 1.307037e+00
R_3556_3557 3556 3557 2.557040e+00
R_3557_3558 3557 3558 4.443783e+00
R_3558_3559 3558 3559 4.809197e+00
R_3559_3560 3559 3560 6.052480e+00
R_3560_3561 3560 3561 5.599797e+00
R_3561_3562 3561 3562 2.053887e-01
R_3562_3563 3562 3563 1.641322e+00
R_3563_3564 3563 3564 1.950680e+00
R_3564_3565 3564 3565 5.534564e+00
R_3565_3566 3565 3566 7.536457e+00
R_3566_3567 3566 3567 1.788616e-01
R_3567_3568 3567 3568 9.093277e+00
R_3568_3569 3568 3569 1.632285e+00
R_3569_3570 3569 3570 9.899740e+00
R_3570_3571 3570 3571 2.416496e+00
R_3571_3572 3571 3572 1.966267e+00
R_3572_3573 3572 3573 3.361971e+00
R_3573_3574 3573 3574 9.796647e+00
R_3574_3575 3574 3575 1.243288e+00
R_3575_3576 3575 3576 1.982916e+00
R_3576_3577 3576 3577 7.566822e+00
R_3577_3578 3577 3578 4.762948e+00
R_3578_3579 3578 3579 8.954750e+00
R_3579_3580 3579 3580 4.610947e+00
R_3580_3581 3580 3581 4.437648e+00
R_3581_3582 3581 3582 5.017909e+00
R_3582_3583 3582 3583 2.384439e+00
R_3583_3584 3583 3584 4.680513e+00
R_3584_3585 3584 3585 3.825551e-01
R_3585_3586 3585 3586 2.686068e+00
R_3586_3587 3586 3587 6.980281e+00
R_3587_3588 3587 3588 3.773369e+00
R_3588_3589 3588 3589 3.214420e+00
R_3589_3590 3589 3590 9.435578e+00
R_3590_3591 3590 3591 6.438316e+00
R_3591_3592 3591 3592 8.144589e+00
R_3592_3593 3592 3593 8.697600e+00
R_3593_3594 3593 3594 4.070962e+00
R_3594_3595 3594 3595 5.348156e+00
R_3595_3596 3595 3596 5.566225e-01
R_3596_3597 3596 3597 1.030909e+00
R_3597_3598 3597 3598 8.089382e+00
R_3598_3599 3598 3599 4.441832e+00
R_3599_3600 3599 3600 2.532102e+00
R_3601_3602 3601 3602 6.363547e+00
R_3602_3603 3602 3603 2.980482e+00
R_3603_3604 3603 3604 2.424799e+00
R_3604_3605 3604 3605 6.895423e+00
R_3605_3606 3605 3606 6.377151e+00
R_3606_3607 3606 3607 5.625515e+00
R_3607_3608 3607 3608 3.631288e+00
R_3608_3609 3608 3609 5.371405e+00
R_3609_3610 3609 3610 1.515413e+00
R_3610_3611 3610 3611 4.888617e+00
R_3611_3612 3611 3612 3.188150e+00
R_3612_3613 3612 3613 9.839895e-02
R_3613_3614 3613 3614 1.172415e+00
R_3614_3615 3614 3615 1.227472e-01
R_3615_3616 3615 3616 9.645287e+00
R_3616_3617 3616 3617 5.463112e+00
R_3617_3618 3617 3618 3.914540e+00
R_3618_3619 3618 3619 8.647683e+00
R_3619_3620 3619 3620 3.250953e+00
R_3620_3621 3620 3621 7.341648e+00
R_3621_3622 3621 3622 8.405982e+00
R_3622_3623 3622 3623 2.222497e+00
R_3623_3624 3623 3624 4.277079e+00
R_3624_3625 3624 3625 7.412171e+00
R_3625_3626 3625 3626 8.830491e+00
R_3626_3627 3626 3627 8.982741e+00
R_3627_3628 3627 3628 1.456564e+00
R_3628_3629 3628 3629 6.284622e+00
R_3629_3630 3629 3630 1.128274e+00
R_3630_3631 3630 3631 8.048397e-01
R_3631_3632 3631 3632 4.285241e+00
R_3632_3633 3632 3633 7.374654e-01
R_3633_3634 3633 3634 4.811195e+00
R_3634_3635 3634 3635 9.754965e+00
R_3635_3636 3635 3636 8.285771e+00
R_3636_3637 3636 3637 8.168343e+00
R_3637_3638 3637 3638 7.075061e+00
R_3638_3639 3638 3639 7.043355e+00
R_3639_3640 3639 3640 2.587816e+00
R_3640_3641 3640 3641 3.120817e+00
R_3641_3642 3641 3642 7.341792e+00
R_3642_3643 3642 3643 1.142258e+00
R_3643_3644 3643 3644 6.038067e+00
R_3644_3645 3644 3645 9.570747e+00
R_3645_3646 3645 3646 4.888473e+00
R_3646_3647 3646 3647 5.571491e+00
R_3647_3648 3647 3648 7.098563e+00
R_3648_3649 3648 3649 5.924966e+00
R_3649_3650 3649 3650 6.513882e+00
R_3650_3651 3650 3651 7.377278e+00
R_3651_3652 3651 3652 4.422892e+00
R_3652_3653 3652 3653 7.146754e+00
R_3653_3654 3653 3654 2.317311e+00
R_3654_3655 3654 3655 6.457730e+00
R_3655_3656 3655 3656 7.029807e+00
R_3656_3657 3656 3657 2.619490e+00
R_3657_3658 3657 3658 1.557586e+00
R_3658_3659 3658 3659 9.219546e+00
R_3659_3660 3659 3660 8.564159e+00
R_3660_3661 3660 3661 7.038326e+00
R_3661_3662 3661 3662 8.231114e+00
R_3662_3663 3662 3663 8.666688e+00
R_3663_3664 3663 3664 5.301671e+00
R_3664_3665 3664 3665 1.604775e+00
R_3665_3666 3665 3666 5.459671e+00
R_3666_3667 3666 3667 6.551343e+00
R_3667_3668 3667 3668 2.573245e+00
R_3668_3669 3668 3669 8.651216e+00
R_3669_3670 3669 3670 7.072674e+00
R_3670_3671 3670 3671 1.232460e+00
R_3671_3672 3671 3672 2.183326e+00
R_3672_3673 3672 3673 1.747007e+00
R_3673_3674 3673 3674 2.444403e+00
R_3674_3675 3674 3675 7.272128e+00
R_3675_3676 3675 3676 8.582022e+00
R_3676_3677 3676 3677 3.144103e-01
R_3677_3678 3677 3678 5.441003e+00
R_3678_3679 3678 3679 9.384997e+00
R_3679_3680 3679 3680 9.139585e+00
R_3680_3681 3680 3681 3.839050e-01
R_3681_3682 3681 3682 6.061180e+00
R_3682_3683 3682 3683 7.424442e+00
R_3683_3684 3683 3684 3.700916e-01
R_3684_3685 3684 3685 8.534271e+00
R_3685_3686 3685 3686 3.306294e+00
R_3686_3687 3686 3687 1.112402e+00
R_3687_3688 3687 3688 3.469845e+00
R_3688_3689 3688 3689 2.894867e+00
R_3689_3690 3689 3690 1.127031e+00
R_3690_3691 3690 3691 8.576565e+00
R_3691_3692 3691 3692 1.364826e+00
R_3692_3693 3692 3693 9.845618e+00
R_3693_3694 3693 3694 2.487464e+00
R_3694_3695 3694 3695 4.515908e+00
R_3695_3696 3695 3696 3.824258e+00
R_3696_3697 3696 3697 4.088664e+00
R_3697_3698 3697 3698 6.435537e+00
R_3698_3699 3698 3699 2.640932e-01
R_3699_3700 3699 3700 4.454551e+00
R_3701_3702 3701 3702 8.700525e+00
R_3702_3703 3702 3703 4.569375e+00
R_3703_3704 3703 3704 6.230639e+00
R_3704_3705 3704 3705 5.859572e+00
R_3705_3706 3705 3706 3.097747e+00
R_3706_3707 3706 3707 3.638697e+00
R_3707_3708 3707 3708 2.521846e+00
R_3708_3709 3708 3709 6.230967e+00
R_3709_3710 3709 3710 2.991960e+00
R_3710_3711 3710 3711 2.944108e+00
R_3711_3712 3711 3712 8.363448e+00
R_3712_3713 3712 3713 2.415556e+00
R_3713_3714 3713 3714 4.368963e+00
R_3714_3715 3714 3715 6.104967e+00
R_3715_3716 3715 3716 1.903851e+00
R_3716_3717 3716 3717 4.794077e+00
R_3717_3718 3717 3718 4.700317e+00
R_3718_3719 3718 3719 9.892279e-01
R_3719_3720 3719 3720 3.713694e+00
R_3720_3721 3720 3721 1.036410e+00
R_3721_3722 3721 3722 6.052213e+00
R_3722_3723 3722 3723 2.167557e+00
R_3723_3724 3723 3724 8.590302e+00
R_3724_3725 3724 3725 7.673765e+00
R_3725_3726 3725 3726 4.694985e+00
R_3726_3727 3726 3727 5.515743e-01
R_3727_3728 3727 3728 8.378262e+00
R_3728_3729 3728 3729 8.510369e-01
R_3729_3730 3729 3730 9.706007e-01
R_3730_3731 3730 3731 8.691170e+00
R_3731_3732 3731 3732 9.222126e+00
R_3732_3733 3732 3733 7.808020e+00
R_3733_3734 3733 3734 3.096937e+00
R_3734_3735 3734 3735 3.303778e+00
R_3735_3736 3735 3736 6.838322e+00
R_3736_3737 3736 3737 8.021899e+00
R_3737_3738 3737 3738 6.269637e+00
R_3738_3739 3738 3739 7.470121e+00
R_3739_3740 3739 3740 7.060961e+00
R_3740_3741 3740 3741 5.222030e+00
R_3741_3742 3741 3742 3.448749e+00
R_3742_3743 3742 3743 5.125076e+00
R_3743_3744 3743 3744 6.014515e+00
R_3744_3745 3744 3745 8.911724e+00
R_3745_3746 3745 3746 6.673494e+00
R_3746_3747 3746 3747 6.073134e+00
R_3747_3748 3747 3748 6.229240e+00
R_3748_3749 3748 3749 3.090185e+00
R_3749_3750 3749 3750 2.451876e+00
R_3750_3751 3750 3751 1.311080e+00
R_3751_3752 3751 3752 2.943889e+00
R_3752_3753 3752 3753 5.662785e+00
R_3753_3754 3753 3754 5.237142e+00
R_3754_3755 3754 3755 6.694605e+00
R_3755_3756 3755 3756 3.325922e+00
R_3756_3757 3756 3757 3.779642e+00
R_3757_3758 3757 3758 5.526630e+00
R_3758_3759 3758 3759 3.468896e+00
R_3759_3760 3759 3760 6.972947e+00
R_3760_3761 3760 3761 8.072639e+00
R_3761_3762 3761 3762 8.326249e+00
R_3762_3763 3762 3763 2.172169e-01
R_3763_3764 3763 3764 7.291674e+00
R_3764_3765 3764 3765 9.038477e+00
R_3765_3766 3765 3766 5.413696e+00
R_3766_3767 3766 3767 3.840034e-01
R_3767_3768 3767 3768 2.309636e+00
R_3768_3769 3768 3769 6.240285e+00
R_3769_3770 3769 3770 3.359760e-01
R_3770_3771 3770 3771 1.359300e+00
R_3771_3772 3771 3772 5.920262e+00
R_3772_3773 3772 3773 6.112639e+00
R_3773_3774 3773 3774 2.009775e+00
R_3774_3775 3774 3775 1.326434e+00
R_3775_3776 3775 3776 2.542787e+00
R_3776_3777 3776 3777 7.715105e+00
R_3777_3778 3777 3778 3.556399e+00
R_3778_3779 3778 3779 3.730649e+00
R_3779_3780 3779 3780 2.113324e+00
R_3780_3781 3780 3781 8.675086e+00
R_3781_3782 3781 3782 3.555792e-01
R_3782_3783 3782 3783 3.705379e-01
R_3783_3784 3783 3784 9.610082e+00
R_3784_3785 3784 3785 8.656071e+00
R_3785_3786 3785 3786 7.043921e+00
R_3786_3787 3786 3787 1.706845e+00
R_3787_3788 3787 3788 3.775373e+00
R_3788_3789 3788 3789 5.570972e+00
R_3789_3790 3789 3790 7.960795e+00
R_3790_3791 3790 3791 6.003917e+00
R_3791_3792 3791 3792 6.029990e-01
R_3792_3793 3792 3793 7.124160e+00
R_3793_3794 3793 3794 7.287097e+00
R_3794_3795 3794 3795 8.692768e+00
R_3795_3796 3795 3796 7.612024e+00
R_3796_3797 3796 3797 3.254108e+00
R_3797_3798 3797 3798 4.647156e+00
R_3798_3799 3798 3799 2.548938e+00
R_3799_3800 3799 3800 7.237094e+00
R_3801_3802 3801 3802 6.383840e+00
R_3802_3803 3802 3803 9.970969e+00
R_3803_3804 3803 3804 5.714038e+00
R_3804_3805 3804 3805 4.953084e+00
R_3805_3806 3805 3806 7.335967e+00
R_3806_3807 3806 3807 3.312328e+00
R_3807_3808 3807 3808 5.822022e+00
R_3808_3809 3808 3809 1.591321e+00
R_3809_3810 3809 3810 1.909922e+00
R_3810_3811 3810 3811 8.545164e+00
R_3811_3812 3811 3812 4.324668e+00
R_3812_3813 3812 3813 7.107929e+00
R_3813_3814 3813 3814 9.924533e+00
R_3814_3815 3814 3815 8.627016e+00
R_3815_3816 3815 3816 8.535432e+00
R_3816_3817 3816 3817 9.656569e+00
R_3817_3818 3817 3818 6.320222e-01
R_3818_3819 3818 3819 8.876920e+00
R_3819_3820 3819 3820 4.863320e+00
R_3820_3821 3820 3821 1.932962e+00
R_3821_3822 3821 3822 4.562999e+00
R_3822_3823 3822 3823 5.327239e+00
R_3823_3824 3823 3824 4.690246e+00
R_3824_3825 3824 3825 1.306091e+00
R_3825_3826 3825 3826 3.939619e+00
R_3826_3827 3826 3827 3.608002e+00
R_3827_3828 3827 3828 9.934486e+00
R_3828_3829 3828 3829 1.989334e+00
R_3829_3830 3829 3830 2.125084e+00
R_3830_3831 3830 3831 2.448364e+00
R_3831_3832 3831 3832 2.569073e+00
R_3832_3833 3832 3833 5.877949e+00
R_3833_3834 3833 3834 1.941578e+00
R_3834_3835 3834 3835 7.260128e+00
R_3835_3836 3835 3836 7.457901e+00
R_3836_3837 3836 3837 8.532037e+00
R_3837_3838 3837 3838 4.199007e+00
R_3838_3839 3838 3839 5.110422e+00
R_3839_3840 3839 3840 7.750490e+00
R_3840_3841 3840 3841 9.538499e+00
R_3841_3842 3841 3842 1.382452e+00
R_3842_3843 3842 3843 1.235016e+00
R_3843_3844 3843 3844 7.510803e+00
R_3844_3845 3844 3845 4.221313e+00
R_3845_3846 3845 3846 3.875752e+00
R_3846_3847 3846 3847 3.837792e+00
R_3847_3848 3847 3848 1.053700e+00
R_3848_3849 3848 3849 3.426786e+00
R_3849_3850 3849 3850 4.936151e+00
R_3850_3851 3850 3851 7.696006e+00
R_3851_3852 3851 3852 8.224770e+00
R_3852_3853 3852 3853 7.787873e+00
R_3853_3854 3853 3854 5.971553e+00
R_3854_3855 3854 3855 6.238710e+00
R_3855_3856 3855 3856 2.892981e+00
R_3856_3857 3856 3857 5.802491e+00
R_3857_3858 3857 3858 6.224092e+00
R_3858_3859 3858 3859 9.019622e+00
R_3859_3860 3859 3860 1.576329e+00
R_3860_3861 3860 3861 8.673882e+00
R_3861_3862 3861 3862 4.907669e+00
R_3862_3863 3862 3863 7.566921e-02
R_3863_3864 3863 3864 9.777184e+00
R_3864_3865 3864 3865 6.762879e+00
R_3865_3866 3865 3866 1.915658e+00
R_3866_3867 3866 3867 6.792512e+00
R_3867_3868 3867 3868 6.783598e+00
R_3868_3869 3868 3869 9.404169e+00
R_3869_3870 3869 3870 5.805032e+00
R_3870_3871 3870 3871 3.567754e-02
R_3871_3872 3871 3872 5.232993e+00
R_3872_3873 3872 3873 8.103463e+00
R_3873_3874 3873 3874 7.429022e+00
R_3874_3875 3874 3875 9.913839e+00
R_3875_3876 3875 3876 6.315057e+00
R_3876_3877 3876 3877 9.117801e+00
R_3877_3878 3877 3878 9.285591e+00
R_3878_3879 3878 3879 2.643138e+00
R_3879_3880 3879 3880 8.804142e+00
R_3880_3881 3880 3881 4.403476e+00
R_3881_3882 3881 3882 5.013867e+00
R_3882_3883 3882 3883 1.078311e+00
R_3883_3884 3883 3884 8.111516e+00
R_3884_3885 3884 3885 6.144959e+00
R_3885_3886 3885 3886 1.858538e+00
R_3886_3887 3886 3887 4.660288e+00
R_3887_3888 3887 3888 6.145816e+00
R_3888_3889 3888 3889 7.257042e+00
R_3889_3890 3889 3890 3.599662e+00
R_3890_3891 3890 3891 3.468717e+00
R_3891_3892 3891 3892 6.903175e+00
R_3892_3893 3892 3893 4.125111e+00
R_3893_3894 3893 3894 9.088916e+00
R_3894_3895 3894 3895 8.081548e+00
R_3895_3896 3895 3896 7.462285e+00
R_3896_3897 3896 3897 9.493403e-01
R_3897_3898 3897 3898 9.147505e+00
R_3898_3899 3898 3899 5.751953e+00
R_3899_3900 3899 3900 6.662952e-01
R_3901_3902 3901 3902 1.633744e+00
R_3902_3903 3902 3903 2.551891e+00
R_3903_3904 3903 3904 9.159603e+00
R_3904_3905 3904 3905 3.275859e+00
R_3905_3906 3905 3906 5.468309e+00
R_3906_3907 3906 3907 9.381542e+00
R_3907_3908 3907 3908 1.201554e+00
R_3908_3909 3908 3909 6.039236e+00
R_3909_3910 3909 3910 2.528618e+00
R_3910_3911 3910 3911 6.284380e-01
R_3911_3912 3911 3912 2.357707e-01
R_3912_3913 3912 3913 2.161991e-01
R_3913_3914 3913 3914 6.832096e+00
R_3914_3915 3914 3915 4.984659e+00
R_3915_3916 3915 3916 9.875765e+00
R_3916_3917 3916 3917 9.778978e-01
R_3917_3918 3917 3918 8.676546e+00
R_3918_3919 3918 3919 9.804747e-01
R_3919_3920 3919 3920 3.223181e+00
R_3920_3921 3920 3921 6.547775e+00
R_3921_3922 3921 3922 4.703030e+00
R_3922_3923 3922 3923 6.746134e+00
R_3923_3924 3923 3924 4.571920e+00
R_3924_3925 3924 3925 8.664033e+00
R_3925_3926 3925 3926 4.214099e+00
R_3926_3927 3926 3927 4.552719e+00
R_3927_3928 3927 3928 3.170886e+00
R_3928_3929 3928 3929 2.116373e+00
R_3929_3930 3929 3930 6.935532e+00
R_3930_3931 3930 3931 5.382346e+00
R_3931_3932 3931 3932 5.280119e+00
R_3932_3933 3932 3933 1.504047e+00
R_3933_3934 3933 3934 6.516613e+00
R_3934_3935 3934 3935 6.914414e+00
R_3935_3936 3935 3936 3.874012e+00
R_3936_3937 3936 3937 9.674977e+00
R_3937_3938 3937 3938 3.535077e+00
R_3938_3939 3938 3939 2.828525e+00
R_3939_3940 3939 3940 1.589594e+00
R_3940_3941 3940 3941 9.460567e+00
R_3941_3942 3941 3942 7.635896e+00
R_3942_3943 3942 3943 2.055052e+00
R_3943_3944 3943 3944 8.550740e+00
R_3944_3945 3944 3945 2.569580e+00
R_3945_3946 3945 3946 5.831835e+00
R_3946_3947 3946 3947 9.536184e+00
R_3947_3948 3947 3948 3.142034e+00
R_3948_3949 3948 3949 4.496379e+00
R_3949_3950 3949 3950 6.164930e+00
R_3950_3951 3950 3951 1.472768e+00
R_3951_3952 3951 3952 2.543940e+00
R_3952_3953 3952 3953 4.983050e+00
R_3953_3954 3953 3954 8.990773e+00
R_3954_3955 3954 3955 1.934803e+00
R_3955_3956 3955 3956 2.542643e-02
R_3956_3957 3956 3957 6.019381e+00
R_3957_3958 3957 3958 8.989696e+00
R_3958_3959 3958 3959 3.361799e+00
R_3959_3960 3959 3960 7.526153e+00
R_3960_3961 3960 3961 8.254198e-01
R_3961_3962 3961 3962 4.076712e+00
R_3962_3963 3962 3963 1.952485e+00
R_3963_3964 3963 3964 8.440570e+00
R_3964_3965 3964 3965 2.404703e-01
R_3965_3966 3965 3966 3.982143e+00
R_3966_3967 3966 3967 8.000785e+00
R_3967_3968 3967 3968 8.185164e+00
R_3968_3969 3968 3969 1.187826e+00
R_3969_3970 3969 3970 6.462555e+00
R_3970_3971 3970 3971 8.922167e+00
R_3971_3972 3971 3972 1.960886e+00
R_3972_3973 3972 3973 6.876026e+00
R_3973_3974 3973 3974 6.451583e+00
R_3974_3975 3974 3975 3.652086e+00
R_3975_3976 3975 3976 6.110362e+00
R_3976_3977 3976 3977 7.279984e+00
R_3977_3978 3977 3978 7.857235e+00
R_3978_3979 3978 3979 2.103443e+00
R_3979_3980 3979 3980 6.146900e-01
R_3980_3981 3980 3981 6.977729e+00
R_3981_3982 3981 3982 9.069661e-01
R_3982_3983 3982 3983 1.961377e+00
R_3983_3984 3983 3984 9.736533e+00
R_3984_3985 3984 3985 7.322001e+00
R_3985_3986 3985 3986 9.860453e-01
R_3986_3987 3986 3987 3.198698e+00
R_3987_3988 3987 3988 4.287574e+00
R_3988_3989 3988 3989 7.854132e+00
R_3989_3990 3989 3990 5.322258e+00
R_3990_3991 3990 3991 2.186781e+00
R_3991_3992 3991 3992 7.508497e+00
R_3992_3993 3992 3993 9.722247e+00
R_3993_3994 3993 3994 5.021665e+00
R_3994_3995 3994 3995 1.625956e+00
R_3995_3996 3995 3996 7.874549e+00
R_3996_3997 3996 3997 6.519681e+00
R_3997_3998 3997 3998 1.548552e+00
R_3998_3999 3998 3999 1.437487e-01
R_3999_4000 3999 4000 9.233506e+00
R_4001_4002 4001 4002 7.259301e+00
R_4002_4003 4002 4003 6.703299e-01
R_4003_4004 4003 4004 1.946716e+00
R_4004_4005 4004 4005 2.794613e+00
R_4005_4006 4005 4006 7.994792e-01
R_4006_4007 4006 4007 2.898352e+00
R_4007_4008 4007 4008 4.544802e-01
R_4008_4009 4008 4009 5.062795e+00
R_4009_4010 4009 4010 2.772201e+00
R_4010_4011 4010 4011 8.142020e+00
R_4011_4012 4011 4012 6.694702e+00
R_4012_4013 4012 4013 3.662653e+00
R_4013_4014 4013 4014 4.226078e+00
R_4014_4015 4014 4015 2.969295e+00
R_4015_4016 4015 4016 6.992689e+00
R_4016_4017 4016 4017 5.248349e+00
R_4017_4018 4017 4018 5.685549e+00
R_4018_4019 4018 4019 6.635336e+00
R_4019_4020 4019 4020 5.008483e+00
R_4020_4021 4020 4021 9.848370e+00
R_4021_4022 4021 4022 7.216109e+00
R_4022_4023 4022 4023 5.121654e-02
R_4023_4024 4023 4024 3.140376e+00
R_4024_4025 4024 4025 6.722384e+00
R_4025_4026 4025 4026 9.336586e+00
R_4026_4027 4026 4027 7.104631e+00
R_4027_4028 4027 4028 7.751261e+00
R_4028_4029 4028 4029 7.317259e+00
R_4029_4030 4029 4030 9.145253e-01
R_4030_4031 4030 4031 8.354553e+00
R_4031_4032 4031 4032 1.364657e+00
R_4032_4033 4032 4033 8.810248e+00
R_4033_4034 4033 4034 1.876143e+00
R_4034_4035 4034 4035 8.583547e+00
R_4035_4036 4035 4036 1.657181e+00
R_4036_4037 4036 4037 8.950761e+00
R_4037_4038 4037 4038 7.175756e+00
R_4038_4039 4038 4039 2.448632e+00
R_4039_4040 4039 4040 1.374820e+00
R_4040_4041 4040 4041 6.802760e+00
R_4041_4042 4041 4042 4.757786e+00
R_4042_4043 4042 4043 3.541102e+00
R_4043_4044 4043 4044 9.098425e+00
R_4044_4045 4044 4045 4.432514e+00
R_4045_4046 4045 4046 3.762752e+00
R_4046_4047 4046 4047 8.231893e+00
R_4047_4048 4047 4048 2.599427e+00
R_4048_4049 4048 4049 4.957464e-01
R_4049_4050 4049 4050 3.357870e-01
R_4050_4051 4050 4051 8.591250e+00
R_4051_4052 4051 4052 1.929323e+00
R_4052_4053 4052 4053 2.802151e+00
R_4053_4054 4053 4054 7.740724e+00
R_4054_4055 4054 4055 3.438874e+00
R_4055_4056 4055 4056 2.088131e+00
R_4056_4057 4056 4057 8.714085e+00
R_4057_4058 4057 4058 2.641926e+00
R_4058_4059 4058 4059 5.164738e+00
R_4059_4060 4059 4060 2.419650e+00
R_4060_4061 4060 4061 2.069620e+00
R_4061_4062 4061 4062 9.058177e+00
R_4062_4063 4062 4063 1.732943e+00
R_4063_4064 4063 4064 3.090798e+00
R_4064_4065 4064 4065 9.983660e+00
R_4065_4066 4065 4066 4.695847e+00
R_4066_4067 4066 4067 3.024158e+00
R_4067_4068 4067 4068 3.547267e+00
R_4068_4069 4068 4069 2.314635e+00
R_4069_4070 4069 4070 3.076504e+00
R_4070_4071 4070 4071 6.779083e+00
R_4071_4072 4071 4072 5.163344e+00
R_4072_4073 4072 4073 6.600450e+00
R_4073_4074 4073 4074 2.724250e+00
R_4074_4075 4074 4075 5.367811e-01
R_4075_4076 4075 4076 8.800114e+00
R_4076_4077 4076 4077 6.096566e+00
R_4077_4078 4077 4078 8.124734e+00
R_4078_4079 4078 4079 9.554878e+00
R_4079_4080 4079 4080 8.747191e+00
R_4080_4081 4080 4081 3.140185e+00
R_4081_4082 4081 4082 7.219206e+00
R_4082_4083 4082 4083 9.662890e+00
R_4083_4084 4083 4084 1.054977e+00
R_4084_4085 4084 4085 7.878815e+00
R_4085_4086 4085 4086 2.143744e+00
R_4086_4087 4086 4087 8.793030e+00
R_4087_4088 4087 4088 7.800877e+00
R_4088_4089 4088 4089 5.095403e+00
R_4089_4090 4089 4090 9.009082e+00
R_4090_4091 4090 4091 2.389899e+00
R_4091_4092 4091 4092 5.716823e-01
R_4092_4093 4092 4093 4.154049e+00
R_4093_4094 4093 4094 3.031502e+00
R_4094_4095 4094 4095 7.068382e+00
R_4095_4096 4095 4096 4.748058e+00
R_4096_4097 4096 4097 7.094040e+00
R_4097_4098 4097 4098 8.104327e+00
R_4098_4099 4098 4099 1.908447e+00
R_4099_4100 4099 4100 8.211131e+00
R_4101_4102 4101 4102 2.489076e+00
R_4102_4103 4102 4103 8.593294e+00
R_4103_4104 4103 4104 5.476108e+00
R_4104_4105 4104 4105 3.932799e+00
R_4105_4106 4105 4106 2.139759e+00
R_4106_4107 4106 4107 3.046646e+00
R_4107_4108 4107 4108 9.265992e+00
R_4108_4109 4108 4109 7.113512e+00
R_4109_4110 4109 4110 5.872505e+00
R_4110_4111 4110 4111 5.969003e+00
R_4111_4112 4111 4112 5.822002e+00
R_4112_4113 4112 4113 9.849206e+00
R_4113_4114 4113 4114 9.251937e+00
R_4114_4115 4114 4115 2.870956e+00
R_4115_4116 4115 4116 9.523335e+00
R_4116_4117 4116 4117 4.413006e+00
R_4117_4118 4117 4118 3.725183e+00
R_4118_4119 4118 4119 3.384299e+00
R_4119_4120 4119 4120 8.483012e+00
R_4120_4121 4120 4121 5.449350e-01
R_4121_4122 4121 4122 2.619175e+00
R_4122_4123 4122 4123 4.297187e-01
R_4123_4124 4123 4124 4.410957e+00
R_4124_4125 4124 4125 1.485773e+00
R_4125_4126 4125 4126 5.882829e-01
R_4126_4127 4126 4127 3.442627e+00
R_4127_4128 4127 4128 6.462321e+00
R_4128_4129 4128 4129 6.623485e+00
R_4129_4130 4129 4130 8.825933e+00
R_4130_4131 4130 4131 1.747554e+00
R_4131_4132 4131 4132 7.196541e+00
R_4132_4133 4132 4133 2.001861e+00
R_4133_4134 4133 4134 1.561588e+00
R_4134_4135 4134 4135 6.814281e+00
R_4135_4136 4135 4136 1.411671e+00
R_4136_4137 4136 4137 5.449180e+00
R_4137_4138 4137 4138 8.095460e+00
R_4138_4139 4138 4139 1.599202e+00
R_4139_4140 4139 4140 3.118553e+00
R_4140_4141 4140 4141 8.558871e+00
R_4141_4142 4141 4142 7.881163e+00
R_4142_4143 4142 4143 4.119204e-01
R_4143_4144 4143 4144 2.187586e-01
R_4144_4145 4144 4145 1.503139e+00
R_4145_4146 4145 4146 1.359579e-01
R_4146_4147 4146 4147 9.677978e+00
R_4147_4148 4147 4148 5.390724e+00
R_4148_4149 4148 4149 5.908559e+00
R_4149_4150 4149 4150 9.425220e+00
R_4150_4151 4150 4151 7.604543e+00
R_4151_4152 4151 4152 6.694118e+00
R_4152_4153 4152 4153 4.514279e+00
R_4153_4154 4153 4154 4.685208e+00
R_4154_4155 4154 4155 3.799390e+00
R_4155_4156 4155 4156 6.732906e+00
R_4156_4157 4156 4157 5.672623e+00
R_4157_4158 4157 4158 8.907094e+00
R_4158_4159 4158 4159 7.031028e+00
R_4159_4160 4159 4160 4.295235e+00
R_4160_4161 4160 4161 7.993096e+00
R_4161_4162 4161 4162 9.067429e+00
R_4162_4163 4162 4163 5.160808e+00
R_4163_4164 4163 4164 2.597491e+00
R_4164_4165 4164 4165 1.791453e+00
R_4165_4166 4165 4166 5.705166e+00
R_4166_4167 4166 4167 5.757120e+00
R_4167_4168 4167 4168 8.491533e+00
R_4168_4169 4168 4169 9.636511e-01
R_4169_4170 4169 4170 4.404532e+00
R_4170_4171 4170 4171 8.375982e+00
R_4171_4172 4171 4172 1.845585e+00
R_4172_4173 4172 4173 1.143687e+00
R_4173_4174 4173 4174 8.726611e+00
R_4174_4175 4174 4175 7.912381e+00
R_4175_4176 4175 4176 5.920683e+00
R_4176_4177 4176 4177 2.863334e+00
R_4177_4178 4177 4178 2.025527e+00
R_4178_4179 4178 4179 5.178075e+00
R_4179_4180 4179 4180 9.505754e+00
R_4180_4181 4180 4181 8.169144e+00
R_4181_4182 4181 4182 3.129949e-01
R_4182_4183 4182 4183 7.036870e+00
R_4183_4184 4183 4184 6.496979e+00
R_4184_4185 4184 4185 5.716700e+00
R_4185_4186 4185 4186 5.293067e+00
R_4186_4187 4186 4187 1.079148e+00
R_4187_4188 4187 4188 1.845986e+00
R_4188_4189 4188 4189 6.742714e+00
R_4189_4190 4189 4190 7.168181e+00
R_4190_4191 4190 4191 8.917012e+00
R_4191_4192 4191 4192 6.580659e+00
R_4192_4193 4192 4193 3.048602e+00
R_4193_4194 4193 4194 4.600512e+00
R_4194_4195 4194 4195 5.967890e+00
R_4195_4196 4195 4196 1.770944e+00
R_4196_4197 4196 4197 9.544710e+00
R_4197_4198 4197 4198 4.769789e+00
R_4198_4199 4198 4199 9.409263e+00
R_4199_4200 4199 4200 8.547132e+00
R_4201_4202 4201 4202 5.763307e+00
R_4202_4203 4202 4203 2.791697e-01
R_4203_4204 4203 4204 8.436547e+00
R_4204_4205 4204 4205 5.840325e+00
R_4205_4206 4205 4206 9.537861e+00
R_4206_4207 4206 4207 2.478945e+00
R_4207_4208 4207 4208 9.591397e+00
R_4208_4209 4208 4209 7.080870e+00
R_4209_4210 4209 4210 7.180413e+00
R_4210_4211 4210 4211 2.664448e+00
R_4211_4212 4211 4212 4.317962e+00
R_4212_4213 4212 4213 7.835632e+00
R_4213_4214 4213 4214 8.743982e+00
R_4214_4215 4214 4215 4.133546e+00
R_4215_4216 4215 4216 9.505666e-01
R_4216_4217 4216 4217 9.514652e+00
R_4217_4218 4217 4218 4.611755e+00
R_4218_4219 4218 4219 8.010832e+00
R_4219_4220 4219 4220 3.520754e+00
R_4220_4221 4220 4221 1.369477e+00
R_4221_4222 4221 4222 5.232268e+00
R_4222_4223 4222 4223 3.654577e+00
R_4223_4224 4223 4224 3.063432e+00
R_4224_4225 4224 4225 3.470910e+00
R_4225_4226 4225 4226 1.534066e+00
R_4226_4227 4226 4227 4.852833e+00
R_4227_4228 4227 4228 5.614943e+00
R_4228_4229 4228 4229 9.712805e+00
R_4229_4230 4229 4230 7.309913e+00
R_4230_4231 4230 4231 9.199647e+00
R_4231_4232 4231 4232 3.645656e+00
R_4232_4233 4232 4233 8.098911e+00
R_4233_4234 4233 4234 8.127703e-02
R_4234_4235 4234 4235 6.369450e+00
R_4235_4236 4235 4236 1.112201e+00
R_4236_4237 4236 4237 3.812816e+00
R_4237_4238 4237 4238 3.348233e+00
R_4238_4239 4238 4239 8.141379e+00
R_4239_4240 4239 4240 9.651913e+00
R_4240_4241 4240 4241 4.379345e+00
R_4241_4242 4241 4242 6.980396e-01
R_4242_4243 4242 4243 6.581131e+00
R_4243_4244 4243 4244 7.630067e+00
R_4244_4245 4244 4245 3.310240e+00
R_4245_4246 4245 4246 4.026753e+00
R_4246_4247 4246 4247 7.848893e+00
R_4247_4248 4247 4248 2.900109e+00
R_4248_4249 4248 4249 5.490354e+00
R_4249_4250 4249 4250 9.407082e+00
R_4250_4251 4250 4251 9.154545e+00
R_4251_4252 4251 4252 7.306841e+00
R_4252_4253 4252 4253 9.714299e+00
R_4253_4254 4253 4254 3.043088e+00
R_4254_4255 4254 4255 1.486363e+00
R_4255_4256 4255 4256 5.877417e+00
R_4256_4257 4256 4257 9.441089e+00
R_4257_4258 4257 4258 2.385123e+00
R_4258_4259 4258 4259 5.473267e+00
R_4259_4260 4259 4260 6.648693e+00
R_4260_4261 4260 4261 8.638868e+00
R_4261_4262 4261 4262 3.364501e-01
R_4262_4263 4262 4263 3.276928e-01
R_4263_4264 4263 4264 4.496124e+00
R_4264_4265 4264 4265 4.264766e+00
R_4265_4266 4265 4266 5.123210e-01
R_4266_4267 4266 4267 8.805438e+00
R_4267_4268 4267 4268 9.290641e+00
R_4268_4269 4268 4269 6.312753e+00
R_4269_4270 4269 4270 9.782173e+00
R_4270_4271 4270 4271 7.555872e+00
R_4271_4272 4271 4272 2.188187e+00
R_4272_4273 4272 4273 3.827530e+00
R_4273_4274 4273 4274 6.750623e-01
R_4274_4275 4274 4275 1.018194e+00
R_4275_4276 4275 4276 9.013266e+00
R_4276_4277 4276 4277 7.280455e+00
R_4277_4278 4277 4278 7.759657e+00
R_4278_4279 4278 4279 9.800856e+00
R_4279_4280 4279 4280 9.750008e+00
R_4280_4281 4280 4281 9.624262e-02
R_4281_4282 4281 4282 8.742892e+00
R_4282_4283 4282 4283 3.741692e+00
R_4283_4284 4283 4284 3.985080e+00
R_4284_4285 4284 4285 4.354282e+00
R_4285_4286 4285 4286 1.679669e+00
R_4286_4287 4286 4287 5.022426e+00
R_4287_4288 4287 4288 6.238516e+00
R_4288_4289 4288 4289 2.788115e+00
R_4289_4290 4289 4290 8.640682e+00
R_4290_4291 4290 4291 8.238244e+00
R_4291_4292 4291 4292 3.976977e+00
R_4292_4293 4292 4293 6.294465e+00
R_4293_4294 4293 4294 1.836261e+00
R_4294_4295 4294 4295 9.089615e+00
R_4295_4296 4295 4296 6.290078e+00
R_4296_4297 4296 4297 5.949172e+00
R_4297_4298 4297 4298 9.909018e+00
R_4298_4299 4298 4299 2.841792e+00
R_4299_4300 4299 4300 6.931719e+00
R_4301_4302 4301 4302 5.749987e+00
R_4302_4303 4302 4303 1.203195e+00
R_4303_4304 4303 4304 6.688916e+00
R_4304_4305 4304 4305 4.937656e+00
R_4305_4306 4305 4306 6.266867e-01
R_4306_4307 4306 4307 5.109684e+00
R_4307_4308 4307 4308 9.528558e+00
R_4308_4309 4308 4309 6.629293e+00
R_4309_4310 4309 4310 7.249621e+00
R_4310_4311 4310 4311 6.291470e+00
R_4311_4312 4311 4312 9.538649e+00
R_4312_4313 4312 4313 4.999644e+00
R_4313_4314 4313 4314 9.819721e+00
R_4314_4315 4314 4315 8.449750e+00
R_4315_4316 4315 4316 4.674183e+00
R_4316_4317 4316 4317 1.591948e+00
R_4317_4318 4317 4318 4.191173e+00
R_4318_4319 4318 4319 9.205139e+00
R_4319_4320 4319 4320 7.226398e+00
R_4320_4321 4320 4321 1.230729e+00
R_4321_4322 4321 4322 8.098421e+00
R_4322_4323 4322 4323 6.065412e+00
R_4323_4324 4323 4324 4.982893e+00
R_4324_4325 4324 4325 9.328893e+00
R_4325_4326 4325 4326 2.278470e+00
R_4326_4327 4326 4327 7.081099e-01
R_4327_4328 4327 4328 5.863596e+00
R_4328_4329 4328 4329 3.245706e+00
R_4329_4330 4329 4330 5.688587e+00
R_4330_4331 4330 4331 5.054356e+00
R_4331_4332 4331 4332 7.172761e+00
R_4332_4333 4332 4333 5.226702e+00
R_4333_4334 4333 4334 7.594124e+00
R_4334_4335 4334 4335 3.823534e+00
R_4335_4336 4335 4336 9.704983e-01
R_4336_4337 4336 4337 9.754111e+00
R_4337_4338 4337 4338 2.537444e+00
R_4338_4339 4338 4339 3.511195e+00
R_4339_4340 4339 4340 2.848609e+00
R_4340_4341 4340 4341 2.609234e+00
R_4341_4342 4341 4342 7.163296e+00
R_4342_4343 4342 4343 3.515894e+00
R_4343_4344 4343 4344 8.568320e+00
R_4344_4345 4344 4345 5.803321e+00
R_4345_4346 4345 4346 1.189961e+00
R_4346_4347 4346 4347 4.599670e-01
R_4347_4348 4347 4348 5.432851e+00
R_4348_4349 4348 4349 9.919142e+00
R_4349_4350 4349 4350 8.966128e+00
R_4350_4351 4350 4351 8.843850e-01
R_4351_4352 4351 4352 9.028331e+00
R_4352_4353 4352 4353 3.738247e+00
R_4353_4354 4353 4354 6.872768e+00
R_4354_4355 4354 4355 3.882423e+00
R_4355_4356 4355 4356 3.061964e+00
R_4356_4357 4356 4357 6.757181e+00
R_4357_4358 4357 4358 2.902120e+00
R_4358_4359 4358 4359 9.555401e+00
R_4359_4360 4359 4360 4.242062e+00
R_4360_4361 4360 4361 4.641641e+00
R_4361_4362 4361 4362 2.772983e+00
R_4362_4363 4362 4363 7.466229e+00
R_4363_4364 4363 4364 6.855266e+00
R_4364_4365 4364 4365 5.082449e+00
R_4365_4366 4365 4366 3.005640e+00
R_4366_4367 4366 4367 8.575793e-01
R_4367_4368 4367 4368 9.995523e+00
R_4368_4369 4368 4369 5.319459e+00
R_4369_4370 4369 4370 5.549880e+00
R_4370_4371 4370 4371 5.086215e+00
R_4371_4372 4371 4372 2.046890e-01
R_4372_4373 4372 4373 6.861063e+00
R_4373_4374 4373 4374 7.327948e+00
R_4374_4375 4374 4375 4.479759e+00
R_4375_4376 4375 4376 7.725969e+00
R_4376_4377 4376 4377 6.128709e+00
R_4377_4378 4377 4378 9.420158e+00
R_4378_4379 4378 4379 6.552575e+00
R_4379_4380 4379 4380 2.272200e-01
R_4380_4381 4380 4381 4.596126e+00
R_4381_4382 4381 4382 5.543380e+00
R_4382_4383 4382 4383 6.799126e+00
R_4383_4384 4383 4384 5.672820e+00
R_4384_4385 4384 4385 2.178728e+00
R_4385_4386 4385 4386 3.496041e+00
R_4386_4387 4386 4387 7.612927e+00
R_4387_4388 4387 4388 2.252048e+00
R_4388_4389 4388 4389 9.215679e+00
R_4389_4390 4389 4390 6.136202e+00
R_4390_4391 4390 4391 6.100882e+00
R_4391_4392 4391 4392 8.547094e+00
R_4392_4393 4392 4393 9.510439e-01
R_4393_4394 4393 4394 5.621054e+00
R_4394_4395 4394 4395 1.374065e+00
R_4395_4396 4395 4396 9.102040e-01
R_4396_4397 4396 4397 6.484885e+00
R_4397_4398 4397 4398 4.181196e+00
R_4398_4399 4398 4399 2.067369e+00
R_4399_4400 4399 4400 6.385309e+00
R_4401_4402 4401 4402 8.843132e+00
R_4402_4403 4402 4403 9.152311e+00
R_4403_4404 4403 4404 5.771748e+00
R_4404_4405 4404 4405 6.840650e+00
R_4405_4406 4405 4406 4.181464e+00
R_4406_4407 4406 4407 7.890388e-01
R_4407_4408 4407 4408 8.769303e+00
R_4408_4409 4408 4409 6.605531e+00
R_4409_4410 4409 4410 1.225304e+00
R_4410_4411 4410 4411 9.619159e+00
R_4411_4412 4411 4412 8.687107e+00
R_4412_4413 4412 4413 3.404929e-01
R_4413_4414 4413 4414 4.585117e+00
R_4414_4415 4414 4415 5.164101e+00
R_4415_4416 4415 4416 6.651604e+00
R_4416_4417 4416 4417 3.281281e+00
R_4417_4418 4417 4418 1.775515e+00
R_4418_4419 4418 4419 6.034735e+00
R_4419_4420 4419 4420 2.619081e+00
R_4420_4421 4420 4421 9.886606e+00
R_4421_4422 4421 4422 7.910108e+00
R_4422_4423 4422 4423 3.429054e+00
R_4423_4424 4423 4424 4.718032e+00
R_4424_4425 4424 4425 9.904333e+00
R_4425_4426 4425 4426 3.951811e-01
R_4426_4427 4426 4427 9.199638e+00
R_4427_4428 4427 4428 4.156072e+00
R_4428_4429 4428 4429 9.364233e+00
R_4429_4430 4429 4430 6.015417e+00
R_4430_4431 4430 4431 9.103733e+00
R_4431_4432 4431 4432 8.098152e-01
R_4432_4433 4432 4433 1.758210e+00
R_4433_4434 4433 4434 8.182835e+00
R_4434_4435 4434 4435 5.209911e+00
R_4435_4436 4435 4436 9.404728e+00
R_4436_4437 4436 4437 5.250493e+00
R_4437_4438 4437 4438 4.233890e+00
R_4438_4439 4438 4439 5.133352e+00
R_4439_4440 4439 4440 6.061843e+00
R_4440_4441 4440 4441 7.770665e+00
R_4441_4442 4441 4442 4.540832e+00
R_4442_4443 4442 4443 1.496695e+00
R_4443_4444 4443 4444 1.538131e+00
R_4444_4445 4444 4445 9.560577e+00
R_4445_4446 4445 4446 5.355359e+00
R_4446_4447 4446 4447 2.790236e+00
R_4447_4448 4447 4448 9.026397e+00
R_4448_4449 4448 4449 3.901906e+00
R_4449_4450 4449 4450 4.465899e+00
R_4450_4451 4450 4451 8.815535e+00
R_4451_4452 4451 4452 2.319540e+00
R_4452_4453 4452 4453 7.346927e+00
R_4453_4454 4453 4454 1.256866e-02
R_4454_4455 4454 4455 9.675329e-01
R_4455_4456 4455 4456 4.324499e+00
R_4456_4457 4456 4457 8.344522e+00
R_4457_4458 4457 4458 6.979257e+00
R_4458_4459 4458 4459 5.249909e+00
R_4459_4460 4459 4460 4.080402e+00
R_4460_4461 4460 4461 3.149927e+00
R_4461_4462 4461 4462 5.500823e+00
R_4462_4463 4462 4463 6.708337e+00
R_4463_4464 4463 4464 5.637843e-01
R_4464_4465 4464 4465 7.394768e+00
R_4465_4466 4465 4466 1.496919e-01
R_4466_4467 4466 4467 4.070939e+00
R_4467_4468 4467 4468 6.448851e-01
R_4468_4469 4468 4469 9.516596e+00
R_4469_4470 4469 4470 6.727978e+00
R_4470_4471 4470 4471 1.939543e+00
R_4471_4472 4471 4472 4.038901e+00
R_4472_4473 4472 4473 8.298304e-01
R_4473_4474 4473 4474 9.385449e+00
R_4474_4475 4474 4475 9.760525e+00
R_4475_4476 4475 4476 6.353499e+00
R_4476_4477 4476 4477 4.700780e+00
R_4477_4478 4477 4478 1.715056e+00
R_4478_4479 4478 4479 4.148114e+00
R_4479_4480 4479 4480 8.163678e-01
R_4480_4481 4480 4481 7.737615e+00
R_4481_4482 4481 4482 2.133237e+00
R_4482_4483 4482 4483 5.616122e+00
R_4483_4484 4483 4484 1.584513e+00
R_4484_4485 4484 4485 5.701009e+00
R_4485_4486 4485 4486 2.944715e+00
R_4486_4487 4486 4487 5.823637e+00
R_4487_4488 4487 4488 1.637893e+00
R_4488_4489 4488 4489 8.096832e-01
R_4489_4490 4489 4490 2.818772e+00
R_4490_4491 4490 4491 7.707589e+00
R_4491_4492 4491 4492 3.896406e+00
R_4492_4493 4492 4493 5.370039e+00
R_4493_4494 4493 4494 4.498949e+00
R_4494_4495 4494 4495 9.392232e+00
R_4495_4496 4495 4496 5.644428e+00
R_4496_4497 4496 4497 2.649212e+00
R_4497_4498 4497 4498 2.619246e+00
R_4498_4499 4498 4499 9.173551e-01
R_4499_4500 4499 4500 1.274666e+00
R_4501_4502 4501 4502 9.791569e+00
R_4502_4503 4502 4503 1.517699e+00
R_4503_4504 4503 4504 9.037374e+00
R_4504_4505 4504 4505 5.829653e+00
R_4505_4506 4505 4506 9.411560e+00
R_4506_4507 4506 4507 8.010771e+00
R_4507_4508 4507 4508 3.367809e+00
R_4508_4509 4508 4509 1.744593e+00
R_4509_4510 4509 4510 5.720721e+00
R_4510_4511 4510 4511 5.591270e-01
R_4511_4512 4511 4512 6.620235e+00
R_4512_4513 4512 4513 5.037323e+00
R_4513_4514 4513 4514 7.168237e+00
R_4514_4515 4514 4515 2.396622e+00
R_4515_4516 4515 4516 5.727163e+00
R_4516_4517 4516 4517 8.748526e+00
R_4517_4518 4517 4518 1.785713e+00
R_4518_4519 4518 4519 5.844442e+00
R_4519_4520 4519 4520 4.930697e+00
R_4520_4521 4520 4521 3.446753e+00
R_4521_4522 4521 4522 6.438637e+00
R_4522_4523 4522 4523 8.963959e+00
R_4523_4524 4523 4524 1.610269e+00
R_4524_4525 4524 4525 3.078768e+00
R_4525_4526 4525 4526 2.034712e+00
R_4526_4527 4526 4527 6.532947e-01
R_4527_4528 4527 4528 9.054900e+00
R_4528_4529 4528 4529 7.619205e+00
R_4529_4530 4529 4530 5.997288e+00
R_4530_4531 4530 4531 1.868755e+00
R_4531_4532 4531 4532 7.040888e+00
R_4532_4533 4532 4533 8.246765e-01
R_4533_4534 4533 4534 1.273968e+00
R_4534_4535 4534 4535 8.218802e+00
R_4535_4536 4535 4536 4.364186e-01
R_4536_4537 4536 4537 5.493162e+00
R_4537_4538 4537 4538 9.381491e+00
R_4538_4539 4538 4539 4.029440e+00
R_4539_4540 4539 4540 3.190774e+00
R_4540_4541 4540 4541 8.115262e+00
R_4541_4542 4541 4542 3.427941e+00
R_4542_4543 4542 4543 4.562509e+00
R_4543_4544 4543 4544 3.148078e+00
R_4544_4545 4544 4545 6.227438e+00
R_4545_4546 4545 4546 5.181428e-02
R_4546_4547 4546 4547 4.031214e+00
R_4547_4548 4547 4548 2.412431e+00
R_4548_4549 4548 4549 7.835760e+00
R_4549_4550 4549 4550 1.728107e+00
R_4550_4551 4550 4551 3.421757e+00
R_4551_4552 4551 4552 1.299437e+00
R_4552_4553 4552 4553 5.215909e-01
R_4553_4554 4553 4554 3.035211e+00
R_4554_4555 4554 4555 5.778950e-01
R_4555_4556 4555 4556 2.088397e+00
R_4556_4557 4556 4557 2.186117e+00
R_4557_4558 4557 4558 5.999323e-01
R_4558_4559 4558 4559 1.742508e-01
R_4559_4560 4559 4560 2.550235e+00
R_4560_4561 4560 4561 8.742221e+00
R_4561_4562 4561 4562 4.912216e+00
R_4562_4563 4562 4563 8.392230e+00
R_4563_4564 4563 4564 3.706956e+00
R_4564_4565 4564 4565 6.453135e+00
R_4565_4566 4565 4566 4.710921e-01
R_4566_4567 4566 4567 4.704465e+00
R_4567_4568 4567 4568 5.234080e+00
R_4568_4569 4568 4569 7.739818e+00
R_4569_4570 4569 4570 7.380352e+00
R_4570_4571 4570 4571 3.357548e-01
R_4571_4572 4571 4572 1.823796e+00
R_4572_4573 4572 4573 7.856078e+00
R_4573_4574 4573 4574 1.842026e+00
R_4574_4575 4574 4575 2.372957e+00
R_4575_4576 4575 4576 1.122320e+00
R_4576_4577 4576 4577 5.453576e+00
R_4577_4578 4577 4578 1.682775e+00
R_4578_4579 4578 4579 4.817283e+00
R_4579_4580 4579 4580 2.218598e+00
R_4580_4581 4580 4581 4.047907e+00
R_4581_4582 4581 4582 7.917096e+00
R_4582_4583 4582 4583 9.465806e+00
R_4583_4584 4583 4584 2.439846e-01
R_4584_4585 4584 4585 2.104189e+00
R_4585_4586 4585 4586 8.679335e+00
R_4586_4587 4586 4587 2.109515e+00
R_4587_4588 4587 4588 2.916068e-01
R_4588_4589 4588 4589 9.726290e+00
R_4589_4590 4589 4590 3.197970e+00
R_4590_4591 4590 4591 5.874390e+00
R_4591_4592 4591 4592 6.930369e+00
R_4592_4593 4592 4593 2.250716e-01
R_4593_4594 4593 4594 7.955533e+00
R_4594_4595 4594 4595 8.517720e+00
R_4595_4596 4595 4596 1.443791e+00
R_4596_4597 4596 4597 1.540833e+00
R_4597_4598 4597 4598 5.805421e+00
R_4598_4599 4598 4599 5.817288e-01
R_4599_4600 4599 4600 9.980396e+00
R_4601_4602 4601 4602 8.495253e+00
R_4602_4603 4602 4603 8.281863e+00
R_4603_4604 4603 4604 2.070095e+00
R_4604_4605 4604 4605 8.099316e+00
R_4605_4606 4605 4606 9.186369e-01
R_4606_4607 4606 4607 9.575891e+00
R_4607_4608 4607 4608 5.933675e+00
R_4608_4609 4608 4609 7.574461e+00
R_4609_4610 4609 4610 9.928238e+00
R_4610_4611 4610 4611 5.426692e+00
R_4611_4612 4611 4612 5.586316e+00
R_4612_4613 4612 4613 9.614427e+00
R_4613_4614 4613 4614 5.923461e+00
R_4614_4615 4614 4615 1.144072e+00
R_4615_4616 4615 4616 5.216919e+00
R_4616_4617 4616 4617 3.755921e+00
R_4617_4618 4617 4618 7.784766e+00
R_4618_4619 4618 4619 6.020909e+00
R_4619_4620 4619 4620 7.449777e+00
R_4620_4621 4620 4621 1.101319e+00
R_4621_4622 4621 4622 1.060966e+00
R_4622_4623 4622 4623 1.898832e-01
R_4623_4624 4623 4624 6.682094e+00
R_4624_4625 4624 4625 9.212755e-01
R_4625_4626 4625 4626 1.844821e+00
R_4626_4627 4626 4627 6.893935e+00
R_4627_4628 4627 4628 6.663692e+00
R_4628_4629 4628 4629 1.635507e+00
R_4629_4630 4629 4630 4.054608e+00
R_4630_4631 4630 4631 3.003892e+00
R_4631_4632 4631 4632 6.555955e+00
R_4632_4633 4632 4633 7.263428e-01
R_4633_4634 4633 4634 9.105895e-01
R_4634_4635 4634 4635 5.760622e+00
R_4635_4636 4635 4636 7.457733e+00
R_4636_4637 4636 4637 9.560098e+00
R_4637_4638 4637 4638 7.517076e+00
R_4638_4639 4638 4639 4.775133e+00
R_4639_4640 4639 4640 1.614912e-01
R_4640_4641 4640 4641 7.943389e+00
R_4641_4642 4641 4642 3.989346e+00
R_4642_4643 4642 4643 7.217894e+00
R_4643_4644 4643 4644 6.432304e-01
R_4644_4645 4644 4645 5.317111e+00
R_4645_4646 4645 4646 4.624693e-01
R_4646_4647 4646 4647 5.905703e+00
R_4647_4648 4647 4648 2.692886e+00
R_4648_4649 4648 4649 1.004840e+00
R_4649_4650 4649 4650 3.987455e+00
R_4650_4651 4650 4651 9.326316e+00
R_4651_4652 4651 4652 2.520616e+00
R_4652_4653 4652 4653 1.453701e+00
R_4653_4654 4653 4654 9.998990e+00
R_4654_4655 4654 4655 6.730188e+00
R_4655_4656 4655 4656 4.130078e+00
R_4656_4657 4656 4657 8.283835e-03
R_4657_4658 4657 4658 1.846663e+00
R_4658_4659 4658 4659 1.274504e+00
R_4659_4660 4659 4660 7.773119e+00
R_4660_4661 4660 4661 5.104335e+00
R_4661_4662 4661 4662 1.049268e+00
R_4662_4663 4662 4663 2.288426e+00
R_4663_4664 4663 4664 6.017484e-01
R_4664_4665 4664 4665 8.851062e+00
R_4665_4666 4665 4666 3.152348e+00
R_4666_4667 4666 4667 3.161231e+00
R_4667_4668 4667 4668 2.304957e+00
R_4668_4669 4668 4669 3.790032e+00
R_4669_4670 4669 4670 9.889100e+00
R_4670_4671 4670 4671 9.785123e+00
R_4671_4672 4671 4672 7.291822e+00
R_4672_4673 4672 4673 4.850285e+00
R_4673_4674 4673 4674 3.733673e-01
R_4674_4675 4674 4675 6.661502e+00
R_4675_4676 4675 4676 3.126525e+00
R_4676_4677 4676 4677 7.796378e+00
R_4677_4678 4677 4678 5.163569e-01
R_4678_4679 4678 4679 5.939789e+00
R_4679_4680 4679 4680 5.855488e+00
R_4680_4681 4680 4681 3.433961e+00
R_4681_4682 4681 4682 5.497554e+00
R_4682_4683 4682 4683 3.987157e+00
R_4683_4684 4683 4684 3.506513e+00
R_4684_4685 4684 4685 9.836813e-01
R_4685_4686 4685 4686 7.078858e+00
R_4686_4687 4686 4687 5.187200e+00
R_4687_4688 4687 4688 9.075727e+00
R_4688_4689 4688 4689 1.232721e+00
R_4689_4690 4689 4690 5.676765e+00
R_4690_4691 4690 4691 4.365764e+00
R_4691_4692 4691 4692 1.124836e+00
R_4692_4693 4692 4693 6.468241e+00
R_4693_4694 4693 4694 7.755378e+00
R_4694_4695 4694 4695 2.840487e+00
R_4695_4696 4695 4696 7.390311e+00
R_4696_4697 4696 4697 6.452466e+00
R_4697_4698 4697 4698 6.582062e-02
R_4698_4699 4698 4699 7.124434e+00
R_4699_4700 4699 4700 5.301705e+00
R_4701_4702 4701 4702 7.642047e+00
R_4702_4703 4702 4703 7.622643e+00
R_4703_4704 4703 4704 6.244290e+00
R_4704_4705 4704 4705 3.874367e+00
R_4705_4706 4705 4706 7.872664e+00
R_4706_4707 4706 4707 4.659975e+00
R_4707_4708 4707 4708 2.314459e+00
R_4708_4709 4708 4709 8.004841e+00
R_4709_4710 4709 4710 6.235112e+00
R_4710_4711 4710 4711 4.608176e+00
R_4711_4712 4711 4712 1.727924e+00
R_4712_4713 4712 4713 9.700541e+00
R_4713_4714 4713 4714 2.366550e+00
R_4714_4715 4714 4715 6.526877e+00
R_4715_4716 4715 4716 9.489456e+00
R_4716_4717 4716 4717 3.442175e+00
R_4717_4718 4717 4718 1.342299e+00
R_4718_4719 4718 4719 4.708066e+00
R_4719_4720 4719 4720 6.804619e+00
R_4720_4721 4720 4721 6.751288e+00
R_4721_4722 4721 4722 2.427293e+00
R_4722_4723 4722 4723 6.163665e+00
R_4723_4724 4723 4724 5.705055e+00
R_4724_4725 4724 4725 2.633189e+00
R_4725_4726 4725 4726 3.265433e-01
R_4726_4727 4726 4727 6.949189e+00
R_4727_4728 4727 4728 7.899616e+00
R_4728_4729 4728 4729 1.895675e+00
R_4729_4730 4729 4730 1.318967e-01
R_4730_4731 4730 4731 8.991624e+00
R_4731_4732 4731 4732 4.346920e+00
R_4732_4733 4732 4733 8.339510e+00
R_4733_4734 4733 4734 1.294613e+00
R_4734_4735 4734 4735 3.914985e-01
R_4735_4736 4735 4736 8.720576e+00
R_4736_4737 4736 4737 5.288101e+00
R_4737_4738 4737 4738 2.007994e+00
R_4738_4739 4738 4739 4.041244e+00
R_4739_4740 4739 4740 4.606668e+00
R_4740_4741 4740 4741 6.515101e+00
R_4741_4742 4741 4742 3.413517e+00
R_4742_4743 4742 4743 1.196537e+00
R_4743_4744 4743 4744 5.055874e+00
R_4744_4745 4744 4745 1.566761e+00
R_4745_4746 4745 4746 2.988845e+00
R_4746_4747 4746 4747 5.157542e+00
R_4747_4748 4747 4748 1.883241e+00
R_4748_4749 4748 4749 9.250593e+00
R_4749_4750 4749 4750 4.804102e+00
R_4750_4751 4750 4751 7.949953e+00
R_4751_4752 4751 4752 6.892317e+00
R_4752_4753 4752 4753 8.157924e+00
R_4753_4754 4753 4754 1.852314e+00
R_4754_4755 4754 4755 3.735732e+00
R_4755_4756 4755 4756 6.744489e+00
R_4756_4757 4756 4757 5.561789e+00
R_4757_4758 4757 4758 5.339328e+00
R_4758_4759 4758 4759 3.311782e+00
R_4759_4760 4759 4760 1.370082e+00
R_4760_4761 4760 4761 8.434066e+00
R_4761_4762 4761 4762 7.362542e+00
R_4762_4763 4762 4763 7.526779e+00
R_4763_4764 4763 4764 9.854458e+00
R_4764_4765 4764 4765 7.275593e-01
R_4765_4766 4765 4766 3.990778e+00
R_4766_4767 4766 4767 3.360402e+00
R_4767_4768 4767 4768 3.904523e+00
R_4768_4769 4768 4769 4.740631e+00
R_4769_4770 4769 4770 3.707713e+00
R_4770_4771 4770 4771 8.035635e+00
R_4771_4772 4771 4772 8.504756e+00
R_4772_4773 4772 4773 4.726725e+00
R_4773_4774 4773 4774 1.279932e+00
R_4774_4775 4774 4775 6.245947e+00
R_4775_4776 4775 4776 3.224494e+00
R_4776_4777 4776 4777 2.495344e+00
R_4777_4778 4777 4778 6.835021e+00
R_4778_4779 4778 4779 9.177079e+00
R_4779_4780 4779 4780 1.826489e+00
R_4780_4781 4780 4781 7.528369e+00
R_4781_4782 4781 4782 7.161034e+00
R_4782_4783 4782 4783 5.779207e+00
R_4783_4784 4783 4784 2.357545e+00
R_4784_4785 4784 4785 9.624345e+00
R_4785_4786 4785 4786 8.876400e+00
R_4786_4787 4786 4787 4.477085e+00
R_4787_4788 4787 4788 5.346488e+00
R_4788_4789 4788 4789 5.076679e+00
R_4789_4790 4789 4790 5.266951e+00
R_4790_4791 4790 4791 2.978509e+00
R_4791_4792 4791 4792 6.257734e+00
R_4792_4793 4792 4793 4.388964e+00
R_4793_4794 4793 4794 8.263555e+00
R_4794_4795 4794 4795 3.426633e+00
R_4795_4796 4795 4796 5.547124e+00
R_4796_4797 4796 4797 8.725708e+00
R_4797_4798 4797 4798 3.049792e+00
R_4798_4799 4798 4799 1.014944e+00
R_4799_4800 4799 4800 9.099578e+00
R_4801_4802 4801 4802 5.155689e+00
R_4802_4803 4802 4803 3.430159e+00
R_4803_4804 4803 4804 4.475230e+00
R_4804_4805 4804 4805 9.744605e+00
R_4805_4806 4805 4806 9.635578e+00
R_4806_4807 4806 4807 7.798083e+00
R_4807_4808 4807 4808 4.565188e+00
R_4808_4809 4808 4809 4.586493e+00
R_4809_4810 4809 4810 3.505280e+00
R_4810_4811 4810 4811 4.440166e+00
R_4811_4812 4811 4812 2.881560e+00
R_4812_4813 4812 4813 3.984949e+00
R_4813_4814 4813 4814 4.836863e+00
R_4814_4815 4814 4815 8.101206e+00
R_4815_4816 4815 4816 5.943625e-01
R_4816_4817 4816 4817 6.845217e+00
R_4817_4818 4817 4818 6.092428e+00
R_4818_4819 4818 4819 1.210982e+00
R_4819_4820 4819 4820 9.139185e+00
R_4820_4821 4820 4821 7.350459e-01
R_4821_4822 4821 4822 9.093299e+00
R_4822_4823 4822 4823 7.062215e+00
R_4823_4824 4823 4824 6.553081e+00
R_4824_4825 4824 4825 6.207106e+00
R_4825_4826 4825 4826 7.201025e+00
R_4826_4827 4826 4827 6.009288e+00
R_4827_4828 4827 4828 7.741188e+00
R_4828_4829 4828 4829 3.620915e+00
R_4829_4830 4829 4830 8.271992e+00
R_4830_4831 4830 4831 6.477042e+00
R_4831_4832 4831 4832 8.084398e+00
R_4832_4833 4832 4833 2.345029e+00
R_4833_4834 4833 4834 9.625471e+00
R_4834_4835 4834 4835 1.948164e+00
R_4835_4836 4835 4836 6.660551e+00
R_4836_4837 4836 4837 3.013469e+00
R_4837_4838 4837 4838 7.848877e+00
R_4838_4839 4838 4839 6.219301e+00
R_4839_4840 4839 4840 7.329477e+00
R_4840_4841 4840 4841 2.190569e+00
R_4841_4842 4841 4842 8.752083e+00
R_4842_4843 4842 4843 7.589839e+00
R_4843_4844 4843 4844 4.291110e+00
R_4844_4845 4844 4845 6.484598e+00
R_4845_4846 4845 4846 6.760240e+00
R_4846_4847 4846 4847 6.163867e+00
R_4847_4848 4847 4848 7.737896e+00
R_4848_4849 4848 4849 1.251450e+00
R_4849_4850 4849 4850 9.118141e+00
R_4850_4851 4850 4851 8.772983e+00
R_4851_4852 4851 4852 9.083816e+00
R_4852_4853 4852 4853 9.077326e+00
R_4853_4854 4853 4854 8.191141e+00
R_4854_4855 4854 4855 2.962964e-01
R_4855_4856 4855 4856 9.778387e+00
R_4856_4857 4856 4857 8.451946e+00
R_4857_4858 4857 4858 9.647886e+00
R_4858_4859 4858 4859 6.840957e+00
R_4859_4860 4859 4860 5.038680e-02
R_4860_4861 4860 4861 4.520490e+00
R_4861_4862 4861 4862 4.793868e-01
R_4862_4863 4862 4863 9.067148e+00
R_4863_4864 4863 4864 8.665305e+00
R_4864_4865 4864 4865 5.022604e+00
R_4865_4866 4865 4866 1.423166e+00
R_4866_4867 4866 4867 9.105379e+00
R_4867_4868 4867 4868 5.215401e+00
R_4868_4869 4868 4869 9.980560e+00
R_4869_4870 4869 4870 2.717805e+00
R_4870_4871 4870 4871 6.766105e+00
R_4871_4872 4871 4872 3.897951e+00
R_4872_4873 4872 4873 8.422260e+00
R_4873_4874 4873 4874 6.790057e+00
R_4874_4875 4874 4875 2.911107e+00
R_4875_4876 4875 4876 8.450657e+00
R_4876_4877 4876 4877 8.908956e+00
R_4877_4878 4877 4878 9.599925e+00
R_4878_4879 4878 4879 7.480365e+00
R_4879_4880 4879 4880 2.023258e+00
R_4880_4881 4880 4881 4.190383e+00
R_4881_4882 4881 4882 7.497745e+00
R_4882_4883 4882 4883 8.743506e+00
R_4883_4884 4883 4884 5.792304e-01
R_4884_4885 4884 4885 8.514345e+00
R_4885_4886 4885 4886 7.835297e+00
R_4886_4887 4886 4887 3.170207e+00
R_4887_4888 4887 4888 5.256085e+00
R_4888_4889 4888 4889 9.846924e+00
R_4889_4890 4889 4890 9.910772e+00
R_4890_4891 4890 4891 7.216093e+00
R_4891_4892 4891 4892 6.876856e+00
R_4892_4893 4892 4893 5.359890e+00
R_4893_4894 4893 4894 5.600585e+00
R_4894_4895 4894 4895 7.108938e+00
R_4895_4896 4895 4896 1.278752e+00
R_4896_4897 4896 4897 3.770833e+00
R_4897_4898 4897 4898 7.350065e+00
R_4898_4899 4898 4899 9.374983e+00
R_4899_4900 4899 4900 7.880562e+00
R_4901_4902 4901 4902 7.505924e+00
R_4902_4903 4902 4903 6.318429e+00
R_4903_4904 4903 4904 9.278619e+00
R_4904_4905 4904 4905 2.727934e+00
R_4905_4906 4905 4906 4.856473e-01
R_4906_4907 4906 4907 8.771669e+00
R_4907_4908 4907 4908 3.627828e+00
R_4908_4909 4908 4909 9.375820e+00
R_4909_4910 4909 4910 1.996502e+00
R_4910_4911 4910 4911 7.530193e+00
R_4911_4912 4911 4912 3.310646e+00
R_4912_4913 4912 4913 8.768979e-01
R_4913_4914 4913 4914 2.453486e-01
R_4914_4915 4914 4915 7.661301e+00
R_4915_4916 4915 4916 7.436414e-01
R_4916_4917 4916 4917 6.043260e-01
R_4917_4918 4917 4918 3.364745e+00
R_4918_4919 4918 4919 2.300379e+00
R_4919_4920 4919 4920 3.928859e+00
R_4920_4921 4920 4921 1.982108e+00
R_4921_4922 4921 4922 3.331922e+00
R_4922_4923 4922 4923 5.354276e+00
R_4923_4924 4923 4924 6.550740e+00
R_4924_4925 4924 4925 1.399287e+00
R_4925_4926 4925 4926 9.342247e+00
R_4926_4927 4926 4927 7.963784e+00
R_4927_4928 4927 4928 4.259401e+00
R_4928_4929 4928 4929 8.229681e+00
R_4929_4930 4929 4930 1.863443e+00
R_4930_4931 4930 4931 3.400815e+00
R_4931_4932 4931 4932 1.416446e-01
R_4932_4933 4932 4933 8.741198e+00
R_4933_4934 4933 4934 5.809396e+00
R_4934_4935 4934 4935 8.324632e+00
R_4935_4936 4935 4936 1.369546e+00
R_4936_4937 4936 4937 8.569138e+00
R_4937_4938 4937 4938 9.050201e+00
R_4938_4939 4938 4939 9.008750e+00
R_4939_4940 4939 4940 8.456845e-01
R_4940_4941 4940 4941 6.423986e+00
R_4941_4942 4941 4942 8.639086e-01
R_4942_4943 4942 4943 6.787409e+00
R_4943_4944 4943 4944 3.167442e+00
R_4944_4945 4944 4945 9.160341e+00
R_4945_4946 4945 4946 2.048422e+00
R_4946_4947 4946 4947 3.911589e+00
R_4947_4948 4947 4948 7.541467e+00
R_4948_4949 4948 4949 3.104023e-01
R_4949_4950 4949 4950 2.815804e+00
R_4950_4951 4950 4951 7.280811e+00
R_4951_4952 4951 4952 8.798023e+00
R_4952_4953 4952 4953 9.714090e+00
R_4953_4954 4953 4954 3.758998e+00
R_4954_4955 4954 4955 2.438873e-01
R_4955_4956 4955 4956 3.828962e+00
R_4956_4957 4956 4957 1.430459e-01
R_4957_4958 4957 4958 2.478543e+00
R_4958_4959 4958 4959 3.519143e+00
R_4959_4960 4959 4960 4.014396e+00
R_4960_4961 4960 4961 1.843904e+00
R_4961_4962 4961 4962 4.777342e+00
R_4962_4963 4962 4963 8.873734e+00
R_4963_4964 4963 4964 9.885821e+00
R_4964_4965 4964 4965 3.795090e+00
R_4965_4966 4965 4966 4.752902e+00
R_4966_4967 4966 4967 7.658151e+00
R_4967_4968 4967 4968 9.072945e+00
R_4968_4969 4968 4969 5.909471e+00
R_4969_4970 4969 4970 6.387590e+00
R_4970_4971 4970 4971 8.242987e-01
R_4971_4972 4971 4972 8.847298e+00
R_4972_4973 4972 4973 6.953425e+00
R_4973_4974 4973 4974 5.898461e-01
R_4974_4975 4974 4975 3.977242e+00
R_4975_4976 4975 4976 3.976719e+00
R_4976_4977 4976 4977 9.608811e+00
R_4977_4978 4977 4978 7.082768e+00
R_4978_4979 4978 4979 8.629190e+00
R_4979_4980 4979 4980 4.416433e-01
R_4980_4981 4980 4981 6.983982e+00
R_4981_4982 4981 4982 5.090444e+00
R_4982_4983 4982 4983 9.547425e-01
R_4983_4984 4983 4984 3.446404e+00
R_4984_4985 4984 4985 3.780310e-01
R_4985_4986 4985 4986 3.130170e+00
R_4986_4987 4986 4987 8.711829e+00
R_4987_4988 4987 4988 5.553535e+00
R_4988_4989 4988 4989 7.800091e+00
R_4989_4990 4989 4990 8.669341e+00
R_4990_4991 4990 4991 1.078616e+00
R_4991_4992 4991 4992 1.231222e+00
R_4992_4993 4992 4993 1.250072e+00
R_4993_4994 4993 4994 3.165469e+00
R_4994_4995 4994 4995 3.108603e+00
R_4995_4996 4995 4996 4.271643e+00
R_4996_4997 4996 4997 1.270410e+00
R_4997_4998 4997 4998 7.338169e+00
R_4998_4999 4998 4999 6.656015e+00
R_4999_5000 4999 5000 6.383304e+00
R_5001_5002 5001 5002 2.519823e+00
R_5002_5003 5002 5003 4.853094e+00
R_5003_5004 5003 5004 8.604103e+00
R_5004_5005 5004 5005 6.298910e+00
R_5005_5006 5005 5006 2.825459e+00
R_5006_5007 5006 5007 6.351471e+00
R_5007_5008 5007 5008 6.866653e+00
R_5008_5009 5008 5009 4.749744e+00
R_5009_5010 5009 5010 4.056866e+00
R_5010_5011 5010 5011 1.959656e+00
R_5011_5012 5011 5012 9.052468e+00
R_5012_5013 5012 5013 6.535412e+00
R_5013_5014 5013 5014 8.946008e+00
R_5014_5015 5014 5015 1.724167e+00
R_5015_5016 5015 5016 7.182044e+00
R_5016_5017 5016 5017 3.452765e+00
R_5017_5018 5017 5018 4.913721e+00
R_5018_5019 5018 5019 9.684048e+00
R_5019_5020 5019 5020 6.523234e+00
R_5020_5021 5020 5021 8.834173e+00
R_5021_5022 5021 5022 1.802031e+00
R_5022_5023 5022 5023 3.816859e+00
R_5023_5024 5023 5024 7.328203e+00
R_5024_5025 5024 5025 4.474337e+00
R_5025_5026 5025 5026 4.475876e+00
R_5026_5027 5026 5027 6.643880e+00
R_5027_5028 5027 5028 9.163870e-01
R_5028_5029 5028 5029 7.849720e-01
R_5029_5030 5029 5030 3.846205e+00
R_5030_5031 5030 5031 9.409728e+00
R_5031_5032 5031 5032 9.174867e+00
R_5032_5033 5032 5033 2.131678e+00
R_5033_5034 5033 5034 2.059959e+00
R_5034_5035 5034 5035 7.354548e+00
R_5035_5036 5035 5036 2.465085e+00
R_5036_5037 5036 5037 4.778905e+00
R_5037_5038 5037 5038 5.202850e+00
R_5038_5039 5038 5039 5.666174e+00
R_5039_5040 5039 5040 1.105236e-01
R_5040_5041 5040 5041 7.306872e+00
R_5041_5042 5041 5042 2.854043e+00
R_5042_5043 5042 5043 1.374597e+00
R_5043_5044 5043 5044 6.171916e+00
R_5044_5045 5044 5045 6.218101e+00
R_5045_5046 5045 5046 8.080598e+00
R_5046_5047 5046 5047 6.996768e+00
R_5047_5048 5047 5048 6.325924e-01
R_5048_5049 5048 5049 9.701243e+00
R_5049_5050 5049 5050 6.590830e+00
R_5050_5051 5050 5051 9.781675e+00
R_5051_5052 5051 5052 4.309484e+00
R_5052_5053 5052 5053 4.249638e+00
R_5053_5054 5053 5054 8.065936e+00
R_5054_5055 5054 5055 2.555749e-01
R_5055_5056 5055 5056 7.513746e+00
R_5056_5057 5056 5057 6.635926e+00
R_5057_5058 5057 5058 1.784450e+00
R_5058_5059 5058 5059 1.682900e+00
R_5059_5060 5059 5060 5.095403e+00
R_5060_5061 5060 5061 6.575775e+00
R_5061_5062 5061 5062 1.953219e+00
R_5062_5063 5062 5063 2.059612e-01
R_5063_5064 5063 5064 5.008086e+00
R_5064_5065 5064 5065 3.320659e+00
R_5065_5066 5065 5066 9.176496e+00
R_5066_5067 5066 5067 9.019494e+00
R_5067_5068 5067 5068 5.895078e+00
R_5068_5069 5068 5069 7.922143e+00
R_5069_5070 5069 5070 1.673765e+00
R_5070_5071 5070 5071 3.841620e+00
R_5071_5072 5071 5072 5.591387e+00
R_5072_5073 5072 5073 5.633865e+00
R_5073_5074 5073 5074 1.009024e-01
R_5074_5075 5074 5075 2.823483e+00
R_5075_5076 5075 5076 6.757895e+00
R_5076_5077 5076 5077 7.841585e+00
R_5077_5078 5077 5078 2.197668e+00
R_5078_5079 5078 5079 8.321661e+00
R_5079_5080 5079 5080 8.114292e+00
R_5080_5081 5080 5081 8.317146e+00
R_5081_5082 5081 5082 6.329505e+00
R_5082_5083 5082 5083 1.613018e+00
R_5083_5084 5083 5084 5.228311e+00
R_5084_5085 5084 5085 6.225876e+00
R_5085_5086 5085 5086 4.521966e+00
R_5086_5087 5086 5087 6.260944e+00
R_5087_5088 5087 5088 6.390767e+00
R_5088_5089 5088 5089 3.609991e+00
R_5089_5090 5089 5090 3.900860e+00
R_5090_5091 5090 5091 4.447168e+00
R_5091_5092 5091 5092 3.708486e+00
R_5092_5093 5092 5093 6.607783e-01
R_5093_5094 5093 5094 5.860730e+00
R_5094_5095 5094 5095 4.731194e+00
R_5095_5096 5095 5096 1.696503e+00
R_5096_5097 5096 5097 6.590216e+00
R_5097_5098 5097 5098 2.614605e+00
R_5098_5099 5098 5099 2.735587e+00
R_5099_5100 5099 5100 9.225407e+00
R_5101_5102 5101 5102 8.397276e+00
R_5102_5103 5102 5103 3.559639e+00
R_5103_5104 5103 5104 3.003546e-01
R_5104_5105 5104 5105 1.896721e+00
R_5105_5106 5105 5106 8.983639e+00
R_5106_5107 5106 5107 6.634280e+00
R_5107_5108 5107 5108 1.104596e+00
R_5108_5109 5108 5109 1.521940e+00
R_5109_5110 5109 5110 1.521074e-01
R_5110_5111 5110 5111 4.176759e+00
R_5111_5112 5111 5112 1.976026e+00
R_5112_5113 5112 5113 8.422072e-01
R_5113_5114 5113 5114 1.409676e-01
R_5114_5115 5114 5115 9.284823e+00
R_5115_5116 5115 5116 1.397607e+00
R_5116_5117 5116 5117 1.645032e+00
R_5117_5118 5117 5118 1.517624e+00
R_5118_5119 5118 5119 1.969977e+00
R_5119_5120 5119 5120 4.745037e+00
R_5120_5121 5120 5121 1.629753e-01
R_5121_5122 5121 5122 7.679630e+00
R_5122_5123 5122 5123 7.590029e+00
R_5123_5124 5123 5124 5.518337e+00
R_5124_5125 5124 5125 9.565653e-01
R_5125_5126 5125 5126 2.477869e+00
R_5126_5127 5126 5127 5.015916e+00
R_5127_5128 5127 5128 3.168426e+00
R_5128_5129 5128 5129 6.958370e+00
R_5129_5130 5129 5130 1.312449e+00
R_5130_5131 5130 5131 8.796426e+00
R_5131_5132 5131 5132 2.795537e+00
R_5132_5133 5132 5133 5.079935e+00
R_5133_5134 5133 5134 5.926000e+00
R_5134_5135 5134 5135 7.799216e+00
R_5135_5136 5135 5136 5.831196e+00
R_5136_5137 5136 5137 7.755431e+00
R_5137_5138 5137 5138 5.824818e+00
R_5138_5139 5138 5139 2.092862e-01
R_5139_5140 5139 5140 8.273180e+00
R_5140_5141 5140 5141 1.579460e+00
R_5141_5142 5141 5142 4.809717e+00
R_5142_5143 5142 5143 1.652566e-01
R_5143_5144 5143 5144 7.267182e+00
R_5144_5145 5144 5145 6.295587e+00
R_5145_5146 5145 5146 8.336889e+00
R_5146_5147 5146 5147 5.260823e-02
R_5147_5148 5147 5148 6.303619e+00
R_5148_5149 5148 5149 6.357765e+00
R_5149_5150 5149 5150 2.518857e+00
R_5150_5151 5150 5151 7.451967e+00
R_5151_5152 5151 5152 6.215875e+00
R_5152_5153 5152 5153 5.251047e-01
R_5153_5154 5153 5154 1.695290e+00
R_5154_5155 5154 5155 9.983962e+00
R_5155_5156 5155 5156 6.919237e+00
R_5156_5157 5156 5157 5.073558e+00
R_5157_5158 5157 5158 1.354054e+00
R_5158_5159 5158 5159 5.485853e+00
R_5159_5160 5159 5160 6.783101e+00
R_5160_5161 5160 5161 8.061857e+00
R_5161_5162 5161 5162 9.932773e+00
R_5162_5163 5162 5163 5.472356e+00
R_5163_5164 5163 5164 6.656684e+00
R_5164_5165 5164 5165 4.828978e+00
R_5165_5166 5165 5166 4.159074e+00
R_5166_5167 5166 5167 2.723950e+00
R_5167_5168 5167 5168 2.619174e+00
R_5168_5169 5168 5169 8.214720e-01
R_5169_5170 5169 5170 3.274538e-01
R_5170_5171 5170 5171 6.191715e+00
R_5171_5172 5171 5172 2.938486e+00
R_5172_5173 5172 5173 5.490690e-01
R_5173_5174 5173 5174 9.307362e+00
R_5174_5175 5174 5175 5.145967e-01
R_5175_5176 5175 5176 2.311140e+00
R_5176_5177 5176 5177 9.708994e+00
R_5177_5178 5177 5178 1.606794e+00
R_5178_5179 5178 5179 7.218942e+00
R_5179_5180 5179 5180 9.079461e-01
R_5180_5181 5180 5181 4.543287e+00
R_5181_5182 5181 5182 1.060508e+00
R_5182_5183 5182 5183 8.343569e+00
R_5183_5184 5183 5184 1.779374e+00
R_5184_5185 5184 5185 6.635770e+00
R_5185_5186 5185 5186 5.991390e+00
R_5186_5187 5186 5187 5.816219e+00
R_5187_5188 5187 5188 9.159099e+00
R_5188_5189 5188 5189 5.461586e+00
R_5189_5190 5189 5190 8.863149e+00
R_5190_5191 5190 5191 5.661050e+00
R_5191_5192 5191 5192 1.466001e+00
R_5192_5193 5192 5193 1.795298e+00
R_5193_5194 5193 5194 5.721230e+00
R_5194_5195 5194 5195 6.066773e+00
R_5195_5196 5195 5196 9.742313e+00
R_5196_5197 5196 5197 8.565318e+00
R_5197_5198 5197 5198 6.604066e+00
R_5198_5199 5198 5199 3.382626e+00
R_5199_5200 5199 5200 9.433082e+00
R_5201_5202 5201 5202 7.390746e-01
R_5202_5203 5202 5203 4.390585e+00
R_5203_5204 5203 5204 4.693371e+00
R_5204_5205 5204 5205 9.551040e-01
R_5205_5206 5205 5206 6.116353e+00
R_5206_5207 5206 5207 8.172945e+00
R_5207_5208 5207 5208 9.528299e+00
R_5208_5209 5208 5209 6.677465e+00
R_5209_5210 5209 5210 7.977715e+00
R_5210_5211 5210 5211 7.974378e+00
R_5211_5212 5211 5212 7.467909e+00
R_5212_5213 5212 5213 2.998629e+00
R_5213_5214 5213 5214 1.756929e+00
R_5214_5215 5214 5215 7.472094e-01
R_5215_5216 5215 5216 7.716971e+00
R_5216_5217 5216 5217 4.490772e-02
R_5217_5218 5217 5218 3.388152e+00
R_5218_5219 5218 5219 3.149127e+00
R_5219_5220 5219 5220 9.151303e+00
R_5220_5221 5220 5221 4.480009e-01
R_5221_5222 5221 5222 3.471076e+00
R_5222_5223 5222 5223 6.103295e+00
R_5223_5224 5223 5224 6.126651e+00
R_5224_5225 5224 5225 4.257070e+00
R_5225_5226 5225 5226 5.386857e+00
R_5226_5227 5226 5227 1.744626e+00
R_5227_5228 5227 5228 9.668485e+00
R_5228_5229 5228 5229 6.201823e+00
R_5229_5230 5229 5230 9.239377e+00
R_5230_5231 5230 5231 8.075645e-01
R_5231_5232 5231 5232 6.393363e+00
R_5232_5233 5232 5233 2.362257e+00
R_5233_5234 5233 5234 3.879057e+00
R_5234_5235 5234 5235 7.983107e+00
R_5235_5236 5235 5236 9.054030e+00
R_5236_5237 5236 5237 6.108879e+00
R_5237_5238 5237 5238 2.908633e+00
R_5238_5239 5238 5239 9.266444e+00
R_5239_5240 5239 5240 7.376995e-01
R_5240_5241 5240 5241 6.577304e+00
R_5241_5242 5241 5242 3.866936e+00
R_5242_5243 5242 5243 3.051242e+00
R_5243_5244 5243 5244 6.744021e+00
R_5244_5245 5244 5245 6.793228e+00
R_5245_5246 5245 5246 6.019189e+00
R_5246_5247 5246 5247 9.966337e+00
R_5247_5248 5247 5248 9.028783e+00
R_5248_5249 5248 5249 3.549339e+00
R_5249_5250 5249 5250 6.854262e+00
R_5250_5251 5250 5251 3.467029e+00
R_5251_5252 5251 5252 3.949837e+00
R_5252_5253 5252 5253 5.596732e+00
R_5253_5254 5253 5254 4.431070e+00
R_5254_5255 5254 5255 5.925286e+00
R_5255_5256 5255 5256 8.007853e+00
R_5256_5257 5256 5257 2.628430e+00
R_5257_5258 5257 5258 5.467502e+00
R_5258_5259 5258 5259 3.390616e+00
R_5259_5260 5259 5260 7.308977e+00
R_5260_5261 5260 5261 7.011818e+00
R_5261_5262 5261 5262 3.647709e+00
R_5262_5263 5262 5263 8.406559e+00
R_5263_5264 5263 5264 6.798399e+00
R_5264_5265 5264 5265 5.573214e+00
R_5265_5266 5265 5266 9.028049e+00
R_5266_5267 5266 5267 4.610441e-01
R_5267_5268 5267 5268 4.583607e+00
R_5268_5269 5268 5269 6.342191e+00
R_5269_5270 5269 5270 3.012699e+00
R_5270_5271 5270 5271 1.862134e+00
R_5271_5272 5271 5272 4.000672e+00
R_5272_5273 5272 5273 7.852218e+00
R_5273_5274 5273 5274 9.709240e+00
R_5274_5275 5274 5275 6.005510e+00
R_5275_5276 5275 5276 9.689248e+00
R_5276_5277 5276 5277 6.703083e-02
R_5277_5278 5277 5278 3.510393e+00
R_5278_5279 5278 5279 5.263323e+00
R_5279_5280 5279 5280 3.990495e-01
R_5280_5281 5280 5281 6.718108e+00
R_5281_5282 5281 5282 3.146296e+00
R_5282_5283 5282 5283 6.098670e+00
R_5283_5284 5283 5284 3.774385e-02
R_5284_5285 5284 5285 5.506079e+00
R_5285_5286 5285 5286 2.851607e+00
R_5286_5287 5286 5287 8.945602e+00
R_5287_5288 5287 5288 5.391861e+00
R_5288_5289 5288 5289 2.707556e+00
R_5289_5290 5289 5290 3.597929e+00
R_5290_5291 5290 5291 9.222014e+00
R_5291_5292 5291 5292 1.351098e+00
R_5292_5293 5292 5293 9.712649e+00
R_5293_5294 5293 5294 9.108222e+00
R_5294_5295 5294 5295 6.706277e+00
R_5295_5296 5295 5296 8.523394e+00
R_5296_5297 5296 5297 8.512173e+00
R_5297_5298 5297 5298 7.076735e+00
R_5298_5299 5298 5299 7.814497e+00
R_5299_5300 5299 5300 6.869415e+00
R_5301_5302 5301 5302 3.601833e+00
R_5302_5303 5302 5303 2.933825e+00
R_5303_5304 5303 5304 9.928754e+00
R_5304_5305 5304 5305 5.364897e+00
R_5305_5306 5305 5306 4.934051e+00
R_5306_5307 5306 5307 4.427658e-01
R_5307_5308 5307 5308 2.151500e+00
R_5308_5309 5308 5309 7.731276e+00
R_5309_5310 5309 5310 3.728617e+00
R_5310_5311 5310 5311 7.483144e+00
R_5311_5312 5311 5312 2.706356e+00
R_5312_5313 5312 5313 2.103609e-01
R_5313_5314 5313 5314 8.491683e+00
R_5314_5315 5314 5315 8.610232e+00
R_5315_5316 5315 5316 7.407878e+00
R_5316_5317 5316 5317 4.527305e+00
R_5317_5318 5317 5318 4.577386e+00
R_5318_5319 5318 5319 1.764918e+00
R_5319_5320 5319 5320 2.902064e+00
R_5320_5321 5320 5321 3.301265e+00
R_5321_5322 5321 5322 2.040001e+00
R_5322_5323 5322 5323 8.773891e+00
R_5323_5324 5323 5324 9.755261e+00
R_5324_5325 5324 5325 8.550687e-01
R_5325_5326 5325 5326 8.297884e+00
R_5326_5327 5326 5327 6.437662e-01
R_5327_5328 5327 5328 6.430956e+00
R_5328_5329 5328 5329 4.589471e+00
R_5329_5330 5329 5330 4.170816e+00
R_5330_5331 5330 5331 9.623589e-01
R_5331_5332 5331 5332 5.566971e-01
R_5332_5333 5332 5333 5.357131e+00
R_5333_5334 5333 5334 9.055289e+00
R_5334_5335 5334 5335 2.786805e+00
R_5335_5336 5335 5336 2.674361e+00
R_5336_5337 5336 5337 6.755899e+00
R_5337_5338 5337 5338 2.586110e+00
R_5338_5339 5338 5339 3.130233e+00
R_5339_5340 5339 5340 3.122843e+00
R_5340_5341 5340 5341 2.333267e+00
R_5341_5342 5341 5342 6.874359e-01
R_5342_5343 5342 5343 5.482440e+00
R_5343_5344 5343 5344 5.268435e+00
R_5344_5345 5344 5345 9.102204e+00
R_5345_5346 5345 5346 6.166185e+00
R_5346_5347 5346 5347 3.415426e+00
R_5347_5348 5347 5348 3.142719e+00
R_5348_5349 5348 5349 7.039720e+00
R_5349_5350 5349 5350 8.605611e+00
R_5350_5351 5350 5351 5.261126e+00
R_5351_5352 5351 5352 2.963777e+00
R_5352_5353 5352 5353 5.867430e+00
R_5353_5354 5353 5354 6.641921e-01
R_5354_5355 5354 5355 5.063452e+00
R_5355_5356 5355 5356 7.693153e+00
R_5356_5357 5356 5357 8.746010e+00
R_5357_5358 5357 5358 9.948469e+00
R_5358_5359 5358 5359 5.119815e+00
R_5359_5360 5359 5360 3.913129e+00
R_5360_5361 5360 5361 2.459168e+00
R_5361_5362 5361 5362 6.117462e+00
R_5362_5363 5362 5363 7.692028e+00
R_5363_5364 5363 5364 1.465415e+00
R_5364_5365 5364 5365 7.085995e+00
R_5365_5366 5365 5366 3.843766e+00
R_5366_5367 5366 5367 1.471718e+00
R_5367_5368 5367 5368 9.265454e+00
R_5368_5369 5368 5369 3.106565e+00
R_5369_5370 5369 5370 7.909636e+00
R_5370_5371 5370 5371 2.644092e+00
R_5371_5372 5371 5372 1.779776e+00
R_5372_5373 5372 5373 4.328173e+00
R_5373_5374 5373 5374 8.773185e+00
R_5374_5375 5374 5375 4.222823e+00
R_5375_5376 5375 5376 8.116826e+00
R_5376_5377 5376 5377 8.253996e+00
R_5377_5378 5377 5378 2.223504e+00
R_5378_5379 5378 5379 9.218467e+00
R_5379_5380 5379 5380 1.752683e-01
R_5380_5381 5380 5381 4.158705e+00
R_5381_5382 5381 5382 8.520105e-01
R_5382_5383 5382 5383 4.260905e+00
R_5383_5384 5383 5384 2.768863e+00
R_5384_5385 5384 5385 3.767653e+00
R_5385_5386 5385 5386 7.284147e+00
R_5386_5387 5386 5387 3.104519e+00
R_5387_5388 5387 5388 7.153943e+00
R_5388_5389 5388 5389 7.383604e-01
R_5389_5390 5389 5390 8.038813e+00
R_5390_5391 5390 5391 2.530179e+00
R_5391_5392 5391 5392 3.118370e+00
R_5392_5393 5392 5393 6.269832e+00
R_5393_5394 5393 5394 3.523776e+00
R_5394_5395 5394 5395 3.610239e+00
R_5395_5396 5395 5396 5.480527e+00
R_5396_5397 5396 5397 1.985876e+00
R_5397_5398 5397 5398 3.388488e+00
R_5398_5399 5398 5399 9.362724e+00
R_5399_5400 5399 5400 5.386627e+00
R_5401_5402 5401 5402 6.790501e+00
R_5402_5403 5402 5403 9.793102e+00
R_5403_5404 5403 5404 4.615681e+00
R_5404_5405 5404 5405 9.770791e+00
R_5405_5406 5405 5406 3.667299e+00
R_5406_5407 5406 5407 9.240958e+00
R_5407_5408 5407 5408 1.958265e+00
R_5408_5409 5408 5409 5.905596e+00
R_5409_5410 5409 5410 7.728587e-01
R_5410_5411 5410 5411 6.944305e+00
R_5411_5412 5411 5412 9.033455e+00
R_5412_5413 5412 5413 9.312602e+00
R_5413_5414 5413 5414 4.065707e+00
R_5414_5415 5414 5415 3.867851e+00
R_5415_5416 5415 5416 3.040517e+00
R_5416_5417 5416 5417 8.497377e+00
R_5417_5418 5417 5418 9.114377e+00
R_5418_5419 5418 5419 4.399719e+00
R_5419_5420 5419 5420 4.892458e+00
R_5420_5421 5420 5421 3.804935e+00
R_5421_5422 5421 5422 4.977034e+00
R_5422_5423 5422 5423 1.709679e+00
R_5423_5424 5423 5424 1.976090e+00
R_5424_5425 5424 5425 6.138515e+00
R_5425_5426 5425 5426 1.879615e+00
R_5426_5427 5426 5427 8.574578e+00
R_5427_5428 5427 5428 8.313933e-01
R_5428_5429 5428 5429 1.956002e+00
R_5429_5430 5429 5430 3.985442e+00
R_5430_5431 5430 5431 3.097562e-02
R_5431_5432 5431 5432 9.624391e+00
R_5432_5433 5432 5433 6.570079e+00
R_5433_5434 5433 5434 7.856470e+00
R_5434_5435 5434 5435 1.995695e+00
R_5435_5436 5435 5436 4.878870e+00
R_5436_5437 5436 5437 2.107829e+00
R_5437_5438 5437 5438 3.167801e+00
R_5438_5439 5438 5439 9.517637e+00
R_5439_5440 5439 5440 2.865882e+00
R_5440_5441 5440 5441 5.616311e+00
R_5441_5442 5441 5442 5.951014e+00
R_5442_5443 5442 5443 2.142838e+00
R_5443_5444 5443 5444 8.159757e+00
R_5444_5445 5444 5445 9.390359e+00
R_5445_5446 5445 5446 7.661095e+00
R_5446_5447 5446 5447 1.118145e-01
R_5447_5448 5447 5448 6.822959e+00
R_5448_5449 5448 5449 2.870778e+00
R_5449_5450 5449 5450 3.852542e+00
R_5450_5451 5450 5451 7.218151e+00
R_5451_5452 5451 5452 9.465471e+00
R_5452_5453 5452 5453 1.187584e+00
R_5453_5454 5453 5454 2.288760e+00
R_5454_5455 5454 5455 8.160473e+00
R_5455_5456 5455 5456 6.758038e+00
R_5456_5457 5456 5457 9.284944e+00
R_5457_5458 5457 5458 4.646945e+00
R_5458_5459 5458 5459 3.463532e+00
R_5459_5460 5459 5460 7.975454e+00
R_5460_5461 5460 5461 4.674766e+00
R_5461_5462 5461 5462 8.904914e+00
R_5462_5463 5462 5463 4.666576e+00
R_5463_5464 5463 5464 5.629206e+00
R_5464_5465 5464 5465 9.657442e+00
R_5465_5466 5465 5466 8.643209e+00
R_5466_5467 5466 5467 8.931410e+00
R_5467_5468 5467 5468 1.486752e+00
R_5468_5469 5468 5469 1.911665e+00
R_5469_5470 5469 5470 6.348166e+00
R_5470_5471 5470 5471 6.457177e+00
R_5471_5472 5471 5472 4.454492e+00
R_5472_5473 5472 5473 8.961427e+00
R_5473_5474 5473 5474 7.214476e+00
R_5474_5475 5474 5475 6.802126e+00
R_5475_5476 5475 5476 7.772341e+00
R_5476_5477 5476 5477 7.077493e+00
R_5477_5478 5477 5478 2.187618e+00
R_5478_5479 5478 5479 3.540628e+00
R_5479_5480 5479 5480 6.543889e+00
R_5480_5481 5480 5481 3.276835e+00
R_5481_5482 5481 5482 4.629452e+00
R_5482_5483 5482 5483 3.694186e+00
R_5483_5484 5483 5484 6.456572e+00
R_5484_5485 5484 5485 1.717692e+00
R_5485_5486 5485 5486 9.492414e+00
R_5486_5487 5486 5487 7.557037e+00
R_5487_5488 5487 5488 7.232965e+00
R_5488_5489 5488 5489 8.495921e+00
R_5489_5490 5489 5490 7.688289e+00
R_5490_5491 5490 5491 3.068738e+00
R_5491_5492 5491 5492 3.759929e+00
R_5492_5493 5492 5493 9.496462e+00
R_5493_5494 5493 5494 4.181854e+00
R_5494_5495 5494 5495 8.966806e+00
R_5495_5496 5495 5496 9.275378e+00
R_5496_5497 5496 5497 2.186626e+00
R_5497_5498 5497 5498 6.835681e+00
R_5498_5499 5498 5499 6.748804e+00
R_5499_5500 5499 5500 4.335309e+00
R_5501_5502 5501 5502 7.659461e+00
R_5502_5503 5502 5503 4.195431e+00
R_5503_5504 5503 5504 7.706630e+00
R_5504_5505 5504 5505 4.755260e+00
R_5505_5506 5505 5506 4.337137e+00
R_5506_5507 5506 5507 1.290691e+00
R_5507_5508 5507 5508 5.110859e+00
R_5508_5509 5508 5509 8.597704e+00
R_5509_5510 5509 5510 2.680257e+00
R_5510_5511 5510 5511 2.959556e+00
R_5511_5512 5511 5512 1.384790e+00
R_5512_5513 5512 5513 7.872006e+00
R_5513_5514 5513 5514 5.473782e-01
R_5514_5515 5514 5515 4.375562e+00
R_5515_5516 5515 5516 4.082349e+00
R_5516_5517 5516 5517 3.199542e+00
R_5517_5518 5517 5518 4.977568e+00
R_5518_5519 5518 5519 2.297446e+00
R_5519_5520 5519 5520 9.942516e+00
R_5520_5521 5520 5521 3.481344e-01
R_5521_5522 5521 5522 9.276225e+00
R_5522_5523 5522 5523 1.546266e+00
R_5523_5524 5523 5524 7.147418e+00
R_5524_5525 5524 5525 8.858164e+00
R_5525_5526 5525 5526 4.922074e+00
R_5526_5527 5526 5527 4.910098e+00
R_5527_5528 5527 5528 3.638864e+00
R_5528_5529 5528 5529 6.703365e+00
R_5529_5530 5529 5530 5.560451e+00
R_5530_5531 5530 5531 6.576727e+00
R_5531_5532 5531 5532 1.582850e+00
R_5532_5533 5532 5533 8.470769e+00
R_5533_5534 5533 5534 2.977243e+00
R_5534_5535 5534 5535 2.757056e+00
R_5535_5536 5535 5536 4.651396e+00
R_5536_5537 5536 5537 3.933846e+00
R_5537_5538 5537 5538 7.321379e+00
R_5538_5539 5538 5539 2.048501e-01
R_5539_5540 5539 5540 8.400420e+00
R_5540_5541 5540 5541 3.755286e+00
R_5541_5542 5541 5542 4.236853e-01
R_5542_5543 5542 5543 1.675342e+00
R_5543_5544 5543 5544 3.969517e+00
R_5544_5545 5544 5545 8.056788e+00
R_5545_5546 5545 5546 8.942783e+00
R_5546_5547 5546 5547 4.364091e+00
R_5547_5548 5547 5548 9.636202e+00
R_5548_5549 5548 5549 9.695900e+00
R_5549_5550 5549 5550 2.535250e-01
R_5550_5551 5550 5551 2.058985e+00
R_5551_5552 5551 5552 1.986091e+00
R_5552_5553 5552 5553 4.132625e+00
R_5553_5554 5553 5554 8.246762e+00
R_5554_5555 5554 5555 6.094493e+00
R_5555_5556 5555 5556 7.102222e+00
R_5556_5557 5556 5557 2.024771e+00
R_5557_5558 5557 5558 3.318111e+00
R_5558_5559 5558 5559 6.964286e+00
R_5559_5560 5559 5560 9.573546e+00
R_5560_5561 5560 5561 4.475256e+00
R_5561_5562 5561 5562 4.587530e+00
R_5562_5563 5562 5563 3.279426e+00
R_5563_5564 5563 5564 4.795918e+00
R_5564_5565 5564 5565 6.504533e+00
R_5565_5566 5565 5566 9.739191e+00
R_5566_5567 5566 5567 5.221201e-01
R_5567_5568 5567 5568 2.177646e+00
R_5568_5569 5568 5569 7.464591e+00
R_5569_5570 5569 5570 5.962548e+00
R_5570_5571 5570 5571 7.452073e+00
R_5571_5572 5571 5572 1.744270e+00
R_5572_5573 5572 5573 2.202385e+00
R_5573_5574 5573 5574 7.375792e-01
R_5574_5575 5574 5575 5.949289e+00
R_5575_5576 5575 5576 9.618496e+00
R_5576_5577 5576 5577 6.537125e-01
R_5577_5578 5577 5578 7.664620e+00
R_5578_5579 5578 5579 6.055728e+00
R_5579_5580 5579 5580 8.167790e+00
R_5580_5581 5580 5581 5.760566e+00
R_5581_5582 5581 5582 6.161469e+00
R_5582_5583 5582 5583 6.719108e+00
R_5583_5584 5583 5584 5.542273e+00
R_5584_5585 5584 5585 8.372394e-01
R_5585_5586 5585 5586 5.722549e+00
R_5586_5587 5586 5587 3.756024e+00
R_5587_5588 5587 5588 5.465644e+00
R_5588_5589 5588 5589 8.870168e+00
R_5589_5590 5589 5590 1.788541e+00
R_5590_5591 5590 5591 1.626273e+00
R_5591_5592 5591 5592 2.698244e+00
R_5592_5593 5592 5593 7.277712e+00
R_5593_5594 5593 5594 1.716238e+00
R_5594_5595 5594 5595 3.658593e+00
R_5595_5596 5595 5596 2.243934e+00
R_5596_5597 5596 5597 4.491561e+00
R_5597_5598 5597 5598 5.662203e+00
R_5598_5599 5598 5599 2.234340e-01
R_5599_5600 5599 5600 2.877440e+00
R_5601_5602 5601 5602 9.084502e+00
R_5602_5603 5602 5603 6.132143e+00
R_5603_5604 5603 5604 9.451876e+00
R_5604_5605 5604 5605 1.637594e+00
R_5605_5606 5605 5606 5.171968e+00
R_5606_5607 5606 5607 9.181060e+00
R_5607_5608 5607 5608 7.179826e-01
R_5608_5609 5608 5609 2.637569e-01
R_5609_5610 5609 5610 7.092337e+00
R_5610_5611 5610 5611 2.892709e+00
R_5611_5612 5611 5612 3.510645e+00
R_5612_5613 5612 5613 1.305021e+00
R_5613_5614 5613 5614 4.075747e+00
R_5614_5615 5614 5615 6.222578e+00
R_5615_5616 5615 5616 6.097314e+00
R_5616_5617 5616 5617 6.585469e+00
R_5617_5618 5617 5618 7.394506e-01
R_5618_5619 5618 5619 8.694137e+00
R_5619_5620 5619 5620 2.748966e+00
R_5620_5621 5620 5621 3.015287e+00
R_5621_5622 5621 5622 1.901049e+00
R_5622_5623 5622 5623 1.065195e+00
R_5623_5624 5623 5624 2.536117e+00
R_5624_5625 5624 5625 4.884552e+00
R_5625_5626 5625 5626 3.825667e+00
R_5626_5627 5626 5627 4.679338e+00
R_5627_5628 5627 5628 8.675002e+00
R_5628_5629 5628 5629 9.203107e+00
R_5629_5630 5629 5630 7.200803e+00
R_5630_5631 5630 5631 9.703305e-01
R_5631_5632 5631 5632 2.026321e+00
R_5632_5633 5632 5633 3.140372e+00
R_5633_5634 5633 5634 2.692003e+00
R_5634_5635 5634 5635 2.914043e-01
R_5635_5636 5635 5636 3.708108e+00
R_5636_5637 5636 5637 3.884610e+00
R_5637_5638 5637 5638 5.799143e+00
R_5638_5639 5638 5639 8.309199e+00
R_5639_5640 5639 5640 7.180723e+00
R_5640_5641 5640 5641 8.923680e+00
R_5641_5642 5641 5642 2.869473e+00
R_5642_5643 5642 5643 1.528048e+00
R_5643_5644 5643 5644 4.287564e+00
R_5644_5645 5644 5645 9.018399e+00
R_5645_5646 5645 5646 4.210283e+00
R_5646_5647 5646 5647 7.291648e+00
R_5647_5648 5647 5648 5.070864e+00
R_5648_5649 5648 5649 9.006410e+00
R_5649_5650 5649 5650 4.491410e+00
R_5650_5651 5650 5651 6.465412e+00
R_5651_5652 5651 5652 1.142094e+00
R_5652_5653 5652 5653 9.000965e+00
R_5653_5654 5653 5654 2.754955e+00
R_5654_5655 5654 5655 5.054988e+00
R_5655_5656 5655 5656 4.212899e+00
R_5656_5657 5656 5657 7.815908e+00
R_5657_5658 5657 5658 6.788557e+00
R_5658_5659 5658 5659 5.238386e+00
R_5659_5660 5659 5660 5.566882e+00
R_5660_5661 5660 5661 2.999312e+00
R_5661_5662 5661 5662 1.833382e+00
R_5662_5663 5662 5663 9.375440e+00
R_5663_5664 5663 5664 9.596246e+00
R_5664_5665 5664 5665 6.480383e+00
R_5665_5666 5665 5666 1.673633e+00
R_5666_5667 5666 5667 8.931881e-01
R_5667_5668 5667 5668 2.455119e+00
R_5668_5669 5668 5669 5.303459e+00
R_5669_5670 5669 5670 2.450668e+00
R_5670_5671 5670 5671 3.030960e+00
R_5671_5672 5671 5672 3.223096e+00
R_5672_5673 5672 5673 8.986111e+00
R_5673_5674 5673 5674 9.611752e-01
R_5674_5675 5674 5675 8.818147e+00
R_5675_5676 5675 5676 9.080830e+00
R_5676_5677 5676 5677 5.170451e+00
R_5677_5678 5677 5678 5.377396e+00
R_5678_5679 5678 5679 5.591334e+00
R_5679_5680 5679 5680 6.733138e+00
R_5680_5681 5680 5681 5.635386e+00
R_5681_5682 5681 5682 5.693635e+00
R_5682_5683 5682 5683 3.897727e+00
R_5683_5684 5683 5684 9.862834e+00
R_5684_5685 5684 5685 3.802693e+00
R_5685_5686 5685 5686 4.996784e+00
R_5686_5687 5686 5687 3.198632e+00
R_5687_5688 5687 5688 3.257646e+00
R_5688_5689 5688 5689 9.027081e+00
R_5689_5690 5689 5690 8.968362e+00
R_5690_5691 5690 5691 7.195133e-01
R_5691_5692 5691 5692 6.125109e+00
R_5692_5693 5692 5693 5.622022e+00
R_5693_5694 5693 5694 5.620435e-01
R_5694_5695 5694 5695 4.159283e+00
R_5695_5696 5695 5696 6.750062e+00
R_5696_5697 5696 5697 3.253083e+00
R_5697_5698 5697 5698 9.426994e+00
R_5698_5699 5698 5699 4.894013e+00
R_5699_5700 5699 5700 6.434417e+00
R_5701_5702 5701 5702 6.795792e+00
R_5702_5703 5702 5703 2.520436e+00
R_5703_5704 5703 5704 3.660615e+00
R_5704_5705 5704 5705 8.802263e+00
R_5705_5706 5705 5706 9.664874e+00
R_5706_5707 5706 5707 6.604788e+00
R_5707_5708 5707 5708 6.057413e+00
R_5708_5709 5708 5709 3.177560e+00
R_5709_5710 5709 5710 1.504789e+00
R_5710_5711 5710 5711 9.735903e+00
R_5711_5712 5711 5712 2.092340e+00
R_5712_5713 5712 5713 2.548626e+00
R_5713_5714 5713 5714 6.170779e+00
R_5714_5715 5714 5715 4.085718e+00
R_5715_5716 5715 5716 6.688347e-01
R_5716_5717 5716 5717 3.219010e+00
R_5717_5718 5717 5718 2.211715e+00
R_5718_5719 5718 5719 5.743116e+00
R_5719_5720 5719 5720 3.310835e+00
R_5720_5721 5720 5721 9.542735e+00
R_5721_5722 5721 5722 8.219964e+00
R_5722_5723 5722 5723 4.417983e+00
R_5723_5724 5723 5724 9.194928e+00
R_5724_5725 5724 5725 8.068785e+00
R_5725_5726 5725 5726 5.160312e+00
R_5726_5727 5726 5727 3.951886e-01
R_5727_5728 5727 5728 3.354156e-01
R_5728_5729 5728 5729 8.644076e+00
R_5729_5730 5729 5730 8.472214e-01
R_5730_5731 5730 5731 7.853533e-01
R_5731_5732 5731 5732 5.115523e+00
R_5732_5733 5732 5733 1.465266e+00
R_5733_5734 5733 5734 6.563141e+00
R_5734_5735 5734 5735 3.317084e+00
R_5735_5736 5735 5736 1.822953e+00
R_5736_5737 5736 5737 9.393545e-01
R_5737_5738 5737 5738 5.789054e+00
R_5738_5739 5738 5739 1.153368e+00
R_5739_5740 5739 5740 8.838834e+00
R_5740_5741 5740 5741 2.661248e+00
R_5741_5742 5741 5742 8.846494e+00
R_5742_5743 5742 5743 6.074262e+00
R_5743_5744 5743 5744 4.665902e+00
R_5744_5745 5744 5745 2.101453e+00
R_5745_5746 5745 5746 6.385851e+00
R_5746_5747 5746 5747 3.424608e+00
R_5747_5748 5747 5748 3.851525e+00
R_5748_5749 5748 5749 5.894512e+00
R_5749_5750 5749 5750 4.250268e+00
R_5750_5751 5750 5751 2.603456e+00
R_5751_5752 5751 5752 8.178540e+00
R_5752_5753 5752 5753 6.376348e-01
R_5753_5754 5753 5754 3.588226e+00
R_5754_5755 5754 5755 1.433066e+00
R_5755_5756 5755 5756 4.585005e+00
R_5756_5757 5756 5757 1.222803e+00
R_5757_5758 5757 5758 9.238996e+00
R_5758_5759 5758 5759 3.314875e+00
R_5759_5760 5759 5760 9.263751e-01
R_5760_5761 5760 5761 2.998196e+00
R_5761_5762 5761 5762 3.830454e+00
R_5762_5763 5762 5763 1.481327e+00
R_5763_5764 5763 5764 6.512636e+00
R_5764_5765 5764 5765 4.002440e+00
R_5765_5766 5765 5766 3.988518e+00
R_5766_5767 5766 5767 8.382801e+00
R_5767_5768 5767 5768 8.283824e+00
R_5768_5769 5768 5769 7.277973e+00
R_5769_5770 5769 5770 2.325286e-01
R_5770_5771 5770 5771 5.691370e+00
R_5771_5772 5771 5772 2.058564e+00
R_5772_5773 5772 5773 7.429808e-02
R_5773_5774 5773 5774 4.150336e+00
R_5774_5775 5774 5775 8.059857e+00
R_5775_5776 5775 5776 9.066058e+00
R_5776_5777 5776 5777 9.268875e+00
R_5777_5778 5777 5778 5.111902e+00
R_5778_5779 5778 5779 1.608764e+00
R_5779_5780 5779 5780 1.900951e+00
R_5780_5781 5780 5781 3.467835e+00
R_5781_5782 5781 5782 2.282221e+00
R_5782_5783 5782 5783 4.739801e+00
R_5783_5784 5783 5784 5.860542e+00
R_5784_5785 5784 5785 6.249915e+00
R_5785_5786 5785 5786 3.603945e+00
R_5786_5787 5786 5787 6.915442e+00
R_5787_5788 5787 5788 2.452655e-01
R_5788_5789 5788 5789 1.968725e+00
R_5789_5790 5789 5790 8.640304e-01
R_5790_5791 5790 5791 2.927488e+00
R_5791_5792 5791 5792 9.442457e-01
R_5792_5793 5792 5793 4.140604e+00
R_5793_5794 5793 5794 8.654381e+00
R_5794_5795 5794 5795 1.111358e-01
R_5795_5796 5795 5796 5.690210e+00
R_5796_5797 5796 5797 1.124259e+00
R_5797_5798 5797 5798 5.641638e+00
R_5798_5799 5798 5799 6.587982e+00
R_5799_5800 5799 5800 2.514575e+00
R_5801_5802 5801 5802 2.629178e-01
R_5802_5803 5802 5803 3.343904e+00
R_5803_5804 5803 5804 8.674063e-01
R_5804_5805 5804 5805 4.752662e-01
R_5805_5806 5805 5806 7.498672e+00
R_5806_5807 5806 5807 3.214242e+00
R_5807_5808 5807 5808 6.091845e+00
R_5808_5809 5808 5809 6.441701e+00
R_5809_5810 5809 5810 9.879746e+00
R_5810_5811 5810 5811 7.788393e+00
R_5811_5812 5811 5812 4.571672e+00
R_5812_5813 5812 5813 7.280780e+00
R_5813_5814 5813 5814 1.335520e-01
R_5814_5815 5814 5815 7.523053e+00
R_5815_5816 5815 5816 1.947273e+00
R_5816_5817 5816 5817 3.198351e+00
R_5817_5818 5817 5818 7.569451e+00
R_5818_5819 5818 5819 4.063067e+00
R_5819_5820 5819 5820 5.719256e+00
R_5820_5821 5820 5821 4.968134e+00
R_5821_5822 5821 5822 6.616082e+00
R_5822_5823 5822 5823 5.698739e+00
R_5823_5824 5823 5824 2.123487e+00
R_5824_5825 5824 5825 7.084240e+00
R_5825_5826 5825 5826 9.957492e+00
R_5826_5827 5826 5827 7.886724e+00
R_5827_5828 5827 5828 7.943234e+00
R_5828_5829 5828 5829 8.687844e+00
R_5829_5830 5829 5830 9.548040e+00
R_5830_5831 5830 5831 8.508988e+00
R_5831_5832 5831 5832 5.435619e+00
R_5832_5833 5832 5833 5.602911e-01
R_5833_5834 5833 5834 9.652418e+00
R_5834_5835 5834 5835 8.539025e+00
R_5835_5836 5835 5836 5.677624e+00
R_5836_5837 5836 5837 2.463251e+00
R_5837_5838 5837 5838 5.878698e+00
R_5838_5839 5838 5839 1.729711e+00
R_5839_5840 5839 5840 1.971520e+00
R_5840_5841 5840 5841 3.886252e+00
R_5841_5842 5841 5842 5.177843e+00
R_5842_5843 5842 5843 1.612177e+00
R_5843_5844 5843 5844 1.720095e+00
R_5844_5845 5844 5845 7.661232e+00
R_5845_5846 5845 5846 9.831666e+00
R_5846_5847 5846 5847 5.289728e+00
R_5847_5848 5847 5848 2.711198e+00
R_5848_5849 5848 5849 5.049976e+00
R_5849_5850 5849 5850 7.449736e+00
R_5850_5851 5850 5851 4.479135e+00
R_5851_5852 5851 5852 6.525895e+00
R_5852_5853 5852 5853 6.794837e+00
R_5853_5854 5853 5854 4.064973e+00
R_5854_5855 5854 5855 1.441955e+00
R_5855_5856 5855 5856 7.315078e+00
R_5856_5857 5856 5857 2.208461e+00
R_5857_5858 5857 5858 8.537899e+00
R_5858_5859 5858 5859 5.803441e+00
R_5859_5860 5859 5860 9.856728e+00
R_5860_5861 5860 5861 7.205494e+00
R_5861_5862 5861 5862 6.139530e+00
R_5862_5863 5862 5863 8.448426e+00
R_5863_5864 5863 5864 5.348359e+00
R_5864_5865 5864 5865 8.946475e+00
R_5865_5866 5865 5866 4.589564e+00
R_5866_5867 5866 5867 8.276191e+00
R_5867_5868 5867 5868 9.468961e+00
R_5868_5869 5868 5869 8.226653e+00
R_5869_5870 5869 5870 7.081902e+00
R_5870_5871 5870 5871 9.540262e+00
R_5871_5872 5871 5872 6.472303e+00
R_5872_5873 5872 5873 9.448470e+00
R_5873_5874 5873 5874 8.149829e+00
R_5874_5875 5874 5875 7.122598e+00
R_5875_5876 5875 5876 8.360835e+00
R_5876_5877 5876 5877 9.639196e+00
R_5877_5878 5877 5878 1.071455e-01
R_5878_5879 5878 5879 4.744821e+00
R_5879_5880 5879 5880 7.947430e+00
R_5880_5881 5880 5881 9.101992e+00
R_5881_5882 5881 5882 7.163319e+00
R_5882_5883 5882 5883 2.688327e+00
R_5883_5884 5883 5884 1.141064e+00
R_5884_5885 5884 5885 9.217813e+00
R_5885_5886 5885 5886 4.722328e-01
R_5886_5887 5886 5887 5.044474e-01
R_5887_5888 5887 5888 4.623683e+00
R_5888_5889 5888 5889 1.004215e+00
R_5889_5890 5889 5890 9.807670e+00
R_5890_5891 5890 5891 3.299056e+00
R_5891_5892 5891 5892 2.671395e+00
R_5892_5893 5892 5893 3.827355e+00
R_5893_5894 5893 5894 1.674287e+00
R_5894_5895 5894 5895 7.887101e+00
R_5895_5896 5895 5896 1.370738e+00
R_5896_5897 5896 5897 4.859672e+00
R_5897_5898 5897 5898 2.577910e+00
R_5898_5899 5898 5899 3.838724e+00
R_5899_5900 5899 5900 1.957568e+00
R_5901_5902 5901 5902 6.907598e+00
R_5902_5903 5902 5903 4.425225e+00
R_5903_5904 5903 5904 4.228693e+00
R_5904_5905 5904 5905 2.983828e+00
R_5905_5906 5905 5906 3.958058e+00
R_5906_5907 5906 5907 5.276657e+00
R_5907_5908 5907 5908 5.405570e+00
R_5908_5909 5908 5909 8.876027e+00
R_5909_5910 5909 5910 4.769630e+00
R_5910_5911 5910 5911 1.716047e+00
R_5911_5912 5911 5912 4.153498e+00
R_5912_5913 5912 5913 8.891767e+00
R_5913_5914 5913 5914 2.726248e+00
R_5914_5915 5914 5915 3.930653e+00
R_5915_5916 5915 5916 8.987129e+00
R_5916_5917 5916 5917 2.035352e+00
R_5917_5918 5917 5918 9.066761e+00
R_5918_5919 5918 5919 2.660882e+00
R_5919_5920 5919 5920 9.209804e+00
R_5920_5921 5920 5921 6.342639e+00
R_5921_5922 5921 5922 6.276203e+00
R_5922_5923 5922 5923 3.365956e+00
R_5923_5924 5923 5924 3.130813e+00
R_5924_5925 5924 5925 7.128219e+00
R_5925_5926 5925 5926 2.606686e+00
R_5926_5927 5926 5927 8.940708e+00
R_5927_5928 5927 5928 5.490805e+00
R_5928_5929 5928 5929 7.355433e+00
R_5929_5930 5929 5930 2.248914e+00
R_5930_5931 5930 5931 2.145452e+00
R_5931_5932 5931 5932 4.963488e+00
R_5932_5933 5932 5933 6.699982e+00
R_5933_5934 5933 5934 8.120245e+00
R_5934_5935 5934 5935 5.673684e+00
R_5935_5936 5935 5936 6.077285e+00
R_5936_5937 5936 5937 4.529947e+00
R_5937_5938 5937 5938 8.039199e+00
R_5938_5939 5938 5939 5.293433e+00
R_5939_5940 5939 5940 6.685390e+00
R_5940_5941 5940 5941 2.722402e+00
R_5941_5942 5941 5942 1.272938e+00
R_5942_5943 5942 5943 4.257042e+00
R_5943_5944 5943 5944 1.639896e+00
R_5944_5945 5944 5945 8.936303e+00
R_5945_5946 5945 5946 3.078429e+00
R_5946_5947 5946 5947 9.112943e+00
R_5947_5948 5947 5948 8.516267e+00
R_5948_5949 5948 5949 9.945139e+00
R_5949_5950 5949 5950 2.643954e+00
R_5950_5951 5950 5951 8.889936e+00
R_5951_5952 5951 5952 1.540383e+00
R_5952_5953 5952 5953 7.673029e+00
R_5953_5954 5953 5954 1.542438e+00
R_5954_5955 5954 5955 8.540656e+00
R_5955_5956 5955 5956 1.868215e+00
R_5956_5957 5956 5957 7.477302e+00
R_5957_5958 5957 5958 1.945473e+00
R_5958_5959 5958 5959 5.773741e+00
R_5959_5960 5959 5960 1.765027e+00
R_5960_5961 5960 5961 8.605363e+00
R_5961_5962 5961 5962 1.535617e+00
R_5962_5963 5962 5963 7.130822e+00
R_5963_5964 5963 5964 9.468693e+00
R_5964_5965 5964 5965 8.551890e+00
R_5965_5966 5965 5966 9.358636e+00
R_5966_5967 5966 5967 8.727682e+00
R_5967_5968 5967 5968 8.507238e+00
R_5968_5969 5968 5969 2.338855e+00
R_5969_5970 5969 5970 9.471350e+00
R_5970_5971 5970 5971 3.353100e+00
R_5971_5972 5971 5972 6.704122e+00
R_5972_5973 5972 5973 9.771122e+00
R_5973_5974 5973 5974 5.921692e+00
R_5974_5975 5974 5975 7.281025e+00
R_5975_5976 5975 5976 4.527564e+00
R_5976_5977 5976 5977 6.227752e+00
R_5977_5978 5977 5978 6.700504e+00
R_5978_5979 5978 5979 8.634270e+00
R_5979_5980 5979 5980 8.451719e+00
R_5980_5981 5980 5981 5.957440e+00
R_5981_5982 5981 5982 3.171946e+00
R_5982_5983 5982 5983 1.057999e+00
R_5983_5984 5983 5984 6.797945e-01
R_5984_5985 5984 5985 5.862817e-02
R_5985_5986 5985 5986 2.467421e+00
R_5986_5987 5986 5987 7.673391e-01
R_5987_5988 5987 5988 6.424133e+00
R_5988_5989 5988 5989 4.895073e+00
R_5989_5990 5989 5990 5.321034e-01
R_5990_5991 5990 5991 2.196285e+00
R_5991_5992 5991 5992 8.616593e+00
R_5992_5993 5992 5993 7.540030e+00
R_5993_5994 5993 5994 1.958662e+00
R_5994_5995 5994 5995 8.219097e+00
R_5995_5996 5995 5996 7.391597e+00
R_5996_5997 5996 5997 9.802257e+00
R_5997_5998 5997 5998 1.234173e+00
R_5998_5999 5998 5999 8.233708e-01
R_5999_6000 5999 6000 6.120292e+00
R_6001_6002 6001 6002 1.320490e+00
R_6002_6003 6002 6003 4.418903e+00
R_6003_6004 6003 6004 7.203848e+00
R_6004_6005 6004 6005 4.923483e+00
R_6005_6006 6005 6006 6.953403e+00
R_6006_6007 6006 6007 8.727849e+00
R_6007_6008 6007 6008 1.233227e+00
R_6008_6009 6008 6009 9.400293e+00
R_6009_6010 6009 6010 3.060149e+00
R_6010_6011 6010 6011 3.893860e+00
R_6011_6012 6011 6012 4.702257e+00
R_6012_6013 6012 6013 2.626693e+00
R_6013_6014 6013 6014 5.551284e+00
R_6014_6015 6014 6015 6.400834e+00
R_6015_6016 6015 6016 9.406425e+00
R_6016_6017 6016 6017 8.471060e-01
R_6017_6018 6017 6018 4.854179e+00
R_6018_6019 6018 6019 8.893576e+00
R_6019_6020 6019 6020 3.348740e+00
R_6020_6021 6020 6021 1.610249e+00
R_6021_6022 6021 6022 2.073327e+00
R_6022_6023 6022 6023 1.602803e+00
R_6023_6024 6023 6024 5.227578e-01
R_6024_6025 6024 6025 7.533186e+00
R_6025_6026 6025 6026 2.067131e+00
R_6026_6027 6026 6027 5.264434e+00
R_6027_6028 6027 6028 9.969276e+00
R_6028_6029 6028 6029 7.227177e-01
R_6029_6030 6029 6030 3.974362e+00
R_6030_6031 6030 6031 1.435979e+00
R_6031_6032 6031 6032 2.799874e+00
R_6032_6033 6032 6033 3.592126e-01
R_6033_6034 6033 6034 2.673308e+00
R_6034_6035 6034 6035 6.311783e-01
R_6035_6036 6035 6036 2.157353e+00
R_6036_6037 6036 6037 2.192353e-01
R_6037_6038 6037 6038 8.288303e+00
R_6038_6039 6038 6039 3.168268e+00
R_6039_6040 6039 6040 1.269295e+00
R_6040_6041 6040 6041 3.171733e+00
R_6041_6042 6041 6042 4.911181e+00
R_6042_6043 6042 6043 8.561339e+00
R_6043_6044 6043 6044 6.461506e+00
R_6044_6045 6044 6045 7.642239e-01
R_6045_6046 6045 6046 9.193776e+00
R_6046_6047 6046 6047 2.980443e+00
R_6047_6048 6047 6048 3.803740e+00
R_6048_6049 6048 6049 5.783613e-01
R_6049_6050 6049 6050 1.747659e+00
R_6050_6051 6050 6051 9.078401e+00
R_6051_6052 6051 6052 1.006122e-01
R_6052_6053 6052 6053 3.296052e+00
R_6053_6054 6053 6054 6.720211e+00
R_6054_6055 6054 6055 4.695363e+00
R_6055_6056 6055 6056 6.125436e-01
R_6056_6057 6056 6057 7.104593e+00
R_6057_6058 6057 6058 1.707592e+00
R_6058_6059 6058 6059 1.542445e+00
R_6059_6060 6059 6060 6.223339e+00
R_6060_6061 6060 6061 1.886550e+00
R_6061_6062 6061 6062 2.609958e+00
R_6062_6063 6062 6063 1.758064e+00
R_6063_6064 6063 6064 7.457840e+00
R_6064_6065 6064 6065 7.110823e+00
R_6065_6066 6065 6066 3.789150e+00
R_6066_6067 6066 6067 1.008886e-01
R_6067_6068 6067 6068 1.964376e+00
R_6068_6069 6068 6069 8.697488e+00
R_6069_6070 6069 6070 7.476427e+00
R_6070_6071 6070 6071 3.336525e+00
R_6071_6072 6071 6072 5.394621e+00
R_6072_6073 6072 6073 5.973565e+00
R_6073_6074 6073 6074 4.972822e+00
R_6074_6075 6074 6075 8.035887e+00
R_6075_6076 6075 6076 4.724854e+00
R_6076_6077 6076 6077 8.212667e+00
R_6077_6078 6077 6078 8.524968e+00
R_6078_6079 6078 6079 3.353102e+00
R_6079_6080 6079 6080 6.574082e+00
R_6080_6081 6080 6081 5.268584e+00
R_6081_6082 6081 6082 9.811227e-01
R_6082_6083 6082 6083 3.347986e+00
R_6083_6084 6083 6084 3.464997e+00
R_6084_6085 6084 6085 1.270663e+00
R_6085_6086 6085 6086 8.424580e+00
R_6086_6087 6086 6087 1.618361e+00
R_6087_6088 6087 6088 7.186069e+00
R_6088_6089 6088 6089 2.622156e+00
R_6089_6090 6089 6090 7.446293e+00
R_6090_6091 6090 6091 9.389736e+00
R_6091_6092 6091 6092 4.364095e+00
R_6092_6093 6092 6093 7.094639e+00
R_6093_6094 6093 6094 9.548545e+00
R_6094_6095 6094 6095 7.527550e+00
R_6095_6096 6095 6096 5.767234e+00
R_6096_6097 6096 6097 1.772462e+00
R_6097_6098 6097 6098 5.560781e+00
R_6098_6099 6098 6099 6.099151e+00
R_6099_6100 6099 6100 8.160505e-01
R_6101_6102 6101 6102 8.208782e+00
R_6102_6103 6102 6103 6.273095e+00
R_6103_6104 6103 6104 6.951906e+00
R_6104_6105 6104 6105 7.929101e+00
R_6105_6106 6105 6106 4.882674e+00
R_6106_6107 6106 6107 4.338227e+00
R_6107_6108 6107 6108 3.209664e+00
R_6108_6109 6108 6109 8.815756e+00
R_6109_6110 6109 6110 3.885941e+00
R_6110_6111 6110 6111 3.231684e-01
R_6111_6112 6111 6112 3.604328e+00
R_6112_6113 6112 6113 6.970608e+00
R_6113_6114 6113 6114 1.635930e+00
R_6114_6115 6114 6115 2.508870e+00
R_6115_6116 6115 6116 8.167295e+00
R_6116_6117 6116 6117 9.194974e+00
R_6117_6118 6117 6118 7.264306e+00
R_6118_6119 6118 6119 4.909926e-01
R_6119_6120 6119 6120 6.938706e-01
R_6120_6121 6120 6121 3.314239e+00
R_6121_6122 6121 6122 8.097644e+00
R_6122_6123 6122 6123 4.208359e+00
R_6123_6124 6123 6124 4.771739e+00
R_6124_6125 6124 6125 4.557480e+00
R_6125_6126 6125 6126 2.145086e+00
R_6126_6127 6126 6127 3.262191e+00
R_6127_6128 6127 6128 9.251057e+00
R_6128_6129 6128 6129 3.825989e+00
R_6129_6130 6129 6130 2.638321e+00
R_6130_6131 6130 6131 3.620530e+00
R_6131_6132 6131 6132 2.456800e+00
R_6132_6133 6132 6133 2.161935e+00
R_6133_6134 6133 6134 4.856571e+00
R_6134_6135 6134 6135 8.494844e+00
R_6135_6136 6135 6136 7.821835e+00
R_6136_6137 6136 6137 9.098298e+00
R_6137_6138 6137 6138 6.483766e-01
R_6138_6139 6138 6139 2.622974e+00
R_6139_6140 6139 6140 5.829056e+00
R_6140_6141 6140 6141 3.688556e+00
R_6141_6142 6141 6142 4.323932e+00
R_6142_6143 6142 6143 3.979860e+00
R_6143_6144 6143 6144 2.498094e+00
R_6144_6145 6144 6145 7.210712e+00
R_6145_6146 6145 6146 8.416164e+00
R_6146_6147 6146 6147 2.533598e+00
R_6147_6148 6147 6148 7.470638e+00
R_6148_6149 6148 6149 2.716509e+00
R_6149_6150 6149 6150 2.485860e+00
R_6150_6151 6150 6151 1.632065e+00
R_6151_6152 6151 6152 9.932209e+00
R_6152_6153 6152 6153 8.852110e+00
R_6153_6154 6153 6154 8.922352e+00
R_6154_6155 6154 6155 8.173696e-01
R_6155_6156 6155 6156 2.772298e+00
R_6156_6157 6156 6157 7.927697e+00
R_6157_6158 6157 6158 2.815846e+00
R_6158_6159 6158 6159 6.393583e+00
R_6159_6160 6159 6160 6.297914e+00
R_6160_6161 6160 6161 2.993615e+00
R_6161_6162 6161 6162 2.285373e+00
R_6162_6163 6162 6163 4.171535e+00
R_6163_6164 6163 6164 5.926533e+00
R_6164_6165 6164 6165 2.422162e-01
R_6165_6166 6165 6166 4.197669e+00
R_6166_6167 6166 6167 6.581376e+00
R_6167_6168 6167 6168 5.400260e+00
R_6168_6169 6168 6169 8.531862e+00
R_6169_6170 6169 6170 4.624376e-01
R_6170_6171 6170 6171 8.831766e+00
R_6171_6172 6171 6172 5.509910e+00
R_6172_6173 6172 6173 2.792139e+00
R_6173_6174 6173 6174 5.802888e+00
R_6174_6175 6174 6175 1.466460e-02
R_6175_6176 6175 6176 7.194147e-01
R_6176_6177 6176 6177 2.387488e+00
R_6177_6178 6177 6178 2.146846e+00
R_6178_6179 6178 6179 5.445050e-02
R_6179_6180 6179 6180 2.677467e+00
R_6180_6181 6180 6181 6.985153e+00
R_6181_6182 6181 6182 4.303421e+00
R_6182_6183 6182 6183 4.238381e+00
R_6183_6184 6183 6184 9.250280e+00
R_6184_6185 6184 6185 9.853583e+00
R_6185_6186 6185 6186 1.606061e+00
R_6186_6187 6186 6187 3.418194e+00
R_6187_6188 6187 6188 1.564623e+00
R_6188_6189 6188 6189 5.918718e+00
R_6189_6190 6189 6190 8.549213e+00
R_6190_6191 6190 6191 7.050517e+00
R_6191_6192 6191 6192 9.296192e+00
R_6192_6193 6192 6193 5.774641e+00
R_6193_6194 6193 6194 4.381487e+00
R_6194_6195 6194 6195 8.857292e+00
R_6195_6196 6195 6196 6.768321e+00
R_6196_6197 6196 6197 2.155214e+00
R_6197_6198 6197 6198 5.164108e+00
R_6198_6199 6198 6199 1.346522e+00
R_6199_6200 6199 6200 3.110115e+00
R_6201_6202 6201 6202 5.259390e+00
R_6202_6203 6202 6203 2.534419e+00
R_6203_6204 6203 6204 3.673881e+00
R_6204_6205 6204 6205 8.792301e+00
R_6205_6206 6205 6206 3.158521e+00
R_6206_6207 6206 6207 1.847665e+00
R_6207_6208 6207 6208 5.014018e+00
R_6208_6209 6208 6209 6.212955e+00
R_6209_6210 6209 6210 8.592221e+00
R_6210_6211 6210 6211 2.305613e+00
R_6211_6212 6211 6212 1.183829e+00
R_6212_6213 6212 6213 8.943835e+00
R_6213_6214 6213 6214 9.994930e+00
R_6214_6215 6214 6215 3.523713e+00
R_6215_6216 6215 6216 2.934869e+00
R_6216_6217 6216 6217 6.046021e+00
R_6217_6218 6217 6218 3.515690e+00
R_6218_6219 6218 6219 2.024078e+00
R_6219_6220 6219 6220 8.726696e+00
R_6220_6221 6220 6221 3.768072e+00
R_6221_6222 6221 6222 2.305996e-01
R_6222_6223 6222 6223 2.451275e+00
R_6223_6224 6223 6224 7.812120e+00
R_6224_6225 6224 6225 8.651442e+00
R_6225_6226 6225 6226 3.964200e+00
R_6226_6227 6226 6227 8.053501e+00
R_6227_6228 6227 6228 5.331246e+00
R_6228_6229 6228 6229 6.569745e+00
R_6229_6230 6229 6230 5.356879e+00
R_6230_6231 6230 6231 5.052760e+00
R_6231_6232 6231 6232 4.607579e-01
R_6232_6233 6232 6233 5.605444e+00
R_6233_6234 6233 6234 8.760832e+00
R_6234_6235 6234 6235 1.906383e+00
R_6235_6236 6235 6236 4.848265e+00
R_6236_6237 6236 6237 4.648934e+00
R_6237_6238 6237 6238 4.639253e+00
R_6238_6239 6238 6239 5.769975e+00
R_6239_6240 6239 6240 9.243128e+00
R_6240_6241 6240 6241 4.923736e+00
R_6241_6242 6241 6242 3.400225e+00
R_6242_6243 6242 6243 6.404309e+00
R_6243_6244 6243 6244 8.550649e+00
R_6244_6245 6244 6245 8.141006e+00
R_6245_6246 6245 6246 4.573196e+00
R_6246_6247 6246 6247 9.098087e+00
R_6247_6248 6247 6248 6.972890e+00
R_6248_6249 6248 6249 3.092677e+00
R_6249_6250 6249 6250 5.142662e+00
R_6250_6251 6250 6251 2.580336e+00
R_6251_6252 6251 6252 5.558036e+00
R_6252_6253 6252 6253 7.158032e+00
R_6253_6254 6253 6254 9.334251e+00
R_6254_6255 6254 6255 1.332481e+00
R_6255_6256 6255 6256 3.638822e+00
R_6256_6257 6256 6257 7.303198e+00
R_6257_6258 6257 6258 6.670724e+00
R_6258_6259 6258 6259 7.768543e-01
R_6259_6260 6259 6260 9.045216e+00
R_6260_6261 6260 6261 5.446749e+00
R_6261_6262 6261 6262 6.126088e+00
R_6262_6263 6262 6263 7.226356e+00
R_6263_6264 6263 6264 5.303721e+00
R_6264_6265 6264 6265 9.267656e+00
R_6265_6266 6265 6266 8.576849e+00
R_6266_6267 6266 6267 9.139304e-01
R_6267_6268 6267 6268 3.511485e+00
R_6268_6269 6268 6269 8.593099e+00
R_6269_6270 6269 6270 8.027066e+00
R_6270_6271 6270 6271 1.895217e+00
R_6271_6272 6271 6272 5.749094e-01
R_6272_6273 6272 6273 3.362176e+00
R_6273_6274 6273 6274 5.378799e+00
R_6274_6275 6274 6275 4.347248e+00
R_6275_6276 6275 6276 8.525003e+00
R_6276_6277 6276 6277 2.730126e+00
R_6277_6278 6277 6278 4.537778e+00
R_6278_6279 6278 6279 9.685462e+00
R_6279_6280 6279 6280 7.521859e+00
R_6280_6281 6280 6281 9.868165e+00
R_6281_6282 6281 6282 5.528455e-01
R_6282_6283 6282 6283 8.526595e+00
R_6283_6284 6283 6284 4.682783e+00
R_6284_6285 6284 6285 7.854927e+00
R_6285_6286 6285 6286 8.079143e+00
R_6286_6287 6286 6287 1.307018e+00
R_6287_6288 6287 6288 9.785720e+00
R_6288_6289 6288 6289 9.690826e+00
R_6289_6290 6289 6290 7.731218e+00
R_6290_6291 6290 6291 6.353413e+00
R_6291_6292 6291 6292 4.892085e+00
R_6292_6293 6292 6293 9.817973e+00
R_6293_6294 6293 6294 8.444414e+00
R_6294_6295 6294 6295 3.959048e+00
R_6295_6296 6295 6296 6.547687e+00
R_6296_6297 6296 6297 7.127831e+00
R_6297_6298 6297 6298 2.481424e+00
R_6298_6299 6298 6299 6.295608e+00
R_6299_6300 6299 6300 2.578388e+00
R_6301_6302 6301 6302 2.753965e+00
R_6302_6303 6302 6303 3.803771e+00
R_6303_6304 6303 6304 3.097022e+00
R_6304_6305 6304 6305 9.656221e+00
R_6305_6306 6305 6306 2.497147e+00
R_6306_6307 6306 6307 1.541093e+00
R_6307_6308 6307 6308 5.675994e+00
R_6308_6309 6308 6309 4.952112e+00
R_6309_6310 6309 6310 8.054609e+00
R_6310_6311 6310 6311 8.569055e+00
R_6311_6312 6311 6312 4.125231e+00
R_6312_6313 6312 6313 8.234556e+00
R_6313_6314 6313 6314 1.494093e+00
R_6314_6315 6314 6315 2.300147e+00
R_6315_6316 6315 6316 3.312998e+00
R_6316_6317 6316 6317 6.894463e+00
R_6317_6318 6317 6318 4.845951e+00
R_6318_6319 6318 6319 9.632035e+00
R_6319_6320 6319 6320 1.412806e+00
R_6320_6321 6320 6321 1.249718e+00
R_6321_6322 6321 6322 5.211501e+00
R_6322_6323 6322 6323 1.642116e+00
R_6323_6324 6323 6324 5.557751e+00
R_6324_6325 6324 6325 9.679985e+00
R_6325_6326 6325 6326 5.397592e+00
R_6326_6327 6326 6327 5.052937e+00
R_6327_6328 6327 6328 1.616468e+00
R_6328_6329 6328 6329 5.482894e+00
R_6329_6330 6329 6330 4.646185e+00
R_6330_6331 6330 6331 9.721983e+00
R_6331_6332 6331 6332 2.567310e+00
R_6332_6333 6332 6333 7.108698e+00
R_6333_6334 6333 6334 3.781847e+00
R_6334_6335 6334 6335 1.469493e+00
R_6335_6336 6335 6336 4.560973e+00
R_6336_6337 6336 6337 2.497862e+00
R_6337_6338 6337 6338 6.752694e+00
R_6338_6339 6338 6339 9.266812e+00
R_6339_6340 6339 6340 2.353462e+00
R_6340_6341 6340 6341 6.964072e+00
R_6341_6342 6341 6342 8.148152e+00
R_6342_6343 6342 6343 4.962237e+00
R_6343_6344 6343 6344 6.309408e+00
R_6344_6345 6344 6345 6.573324e+00
R_6345_6346 6345 6346 6.283255e+00
R_6346_6347 6346 6347 5.180036e+00
R_6347_6348 6347 6348 1.630113e+00
R_6348_6349 6348 6349 7.788815e+00
R_6349_6350 6349 6350 9.915928e+00
R_6350_6351 6350 6351 4.791581e+00
R_6351_6352 6351 6352 6.904064e+00
R_6352_6353 6352 6353 6.979562e+00
R_6353_6354 6353 6354 1.634491e+00
R_6354_6355 6354 6355 7.051052e+00
R_6355_6356 6355 6356 8.050136e+00
R_6356_6357 6356 6357 4.891676e+00
R_6357_6358 6357 6358 6.798865e+00
R_6358_6359 6358 6359 1.511138e+00
R_6359_6360 6359 6360 6.040890e+00
R_6360_6361 6360 6361 5.387804e+00
R_6361_6362 6361 6362 7.804104e+00
R_6362_6363 6362 6363 4.854821e+00
R_6363_6364 6363 6364 1.761628e+00
R_6364_6365 6364 6365 8.787084e+00
R_6365_6366 6365 6366 3.570998e+00
R_6366_6367 6366 6367 1.724994e+00
R_6367_6368 6367 6368 3.093961e+00
R_6368_6369 6368 6369 6.989493e+00
R_6369_6370 6369 6370 2.261801e+00
R_6370_6371 6370 6371 6.878420e+00
R_6371_6372 6371 6372 9.429170e+00
R_6372_6373 6372 6373 1.400726e+00
R_6373_6374 6373 6374 2.591849e+00
R_6374_6375 6374 6375 2.337054e+00
R_6375_6376 6375 6376 1.075411e+00
R_6376_6377 6376 6377 2.030628e+00
R_6377_6378 6377 6378 5.796092e+00
R_6378_6379 6378 6379 5.695573e+00
R_6379_6380 6379 6380 9.423568e+00
R_6380_6381 6380 6381 5.301416e+00
R_6381_6382 6381 6382 3.910711e+00
R_6382_6383 6382 6383 1.672449e+00
R_6383_6384 6383 6384 9.521131e+00
R_6384_6385 6384 6385 8.558339e+00
R_6385_6386 6385 6386 6.514974e+00
R_6386_6387 6386 6387 3.918541e+00
R_6387_6388 6387 6388 4.600869e+00
R_6388_6389 6388 6389 2.718689e+00
R_6389_6390 6389 6390 6.532739e+00
R_6390_6391 6390 6391 3.361346e-01
R_6391_6392 6391 6392 4.736229e+00
R_6392_6393 6392 6393 8.330988e+00
R_6393_6394 6393 6394 3.171138e-01
R_6394_6395 6394 6395 1.268546e+00
R_6395_6396 6395 6396 2.444672e+00
R_6396_6397 6396 6397 3.926315e+00
R_6397_6398 6397 6398 1.891779e+00
R_6398_6399 6398 6399 1.863408e+00
R_6399_6400 6399 6400 7.852398e+00
R_6401_6402 6401 6402 4.670029e+00
R_6402_6403 6402 6403 4.957500e+00
R_6403_6404 6403 6404 2.374584e+00
R_6404_6405 6404 6405 3.735242e+00
R_6405_6406 6405 6406 8.259378e+00
R_6406_6407 6406 6407 8.871063e+00
R_6407_6408 6407 6408 7.241816e+00
R_6408_6409 6408 6409 7.712814e+00
R_6409_6410 6409 6410 5.095069e-01
R_6410_6411 6410 6411 4.413106e+00
R_6411_6412 6411 6412 4.043208e-01
R_6412_6413 6412 6413 3.508381e+00
R_6413_6414 6413 6414 7.398619e+00
R_6414_6415 6414 6415 5.847968e+00
R_6415_6416 6415 6416 2.880328e+00
R_6416_6417 6416 6417 2.404669e+00
R_6417_6418 6417 6418 1.749138e+00
R_6418_6419 6418 6419 9.384066e+00
R_6419_6420 6419 6420 4.567580e+00
R_6420_6421 6420 6421 4.492737e-01
R_6421_6422 6421 6422 2.284492e+00
R_6422_6423 6422 6423 2.497743e+00
R_6423_6424 6423 6424 1.998640e+00
R_6424_6425 6424 6425 3.459222e+00
R_6425_6426 6425 6426 3.541324e+00
R_6426_6427 6426 6427 6.964932e+00
R_6427_6428 6427 6428 1.997897e-01
R_6428_6429 6428 6429 8.995262e+00
R_6429_6430 6429 6430 7.825153e+00
R_6430_6431 6430 6431 3.809440e+00
R_6431_6432 6431 6432 5.710123e+00
R_6432_6433 6432 6433 4.214224e+00
R_6433_6434 6433 6434 9.013074e+00
R_6434_6435 6434 6435 9.517986e+00
R_6435_6436 6435 6436 2.527717e+00
R_6436_6437 6436 6437 7.306583e+00
R_6437_6438 6437 6438 1.849756e+00
R_6438_6439 6438 6439 1.721101e+00
R_6439_6440 6439 6440 1.918187e+00
R_6440_6441 6440 6441 5.782284e+00
R_6441_6442 6441 6442 6.761372e+00
R_6442_6443 6442 6443 9.315351e+00
R_6443_6444 6443 6444 3.055549e+00
R_6444_6445 6444 6445 2.086922e+00
R_6445_6446 6445 6446 2.552222e+00
R_6446_6447 6446 6447 8.254745e+00
R_6447_6448 6447 6448 7.922881e+00
R_6448_6449 6448 6449 3.768097e+00
R_6449_6450 6449 6450 3.002815e+00
R_6450_6451 6450 6451 7.300778e+00
R_6451_6452 6451 6452 8.192445e+00
R_6452_6453 6452 6453 6.446893e+00
R_6453_6454 6453 6454 9.323464e+00
R_6454_6455 6454 6455 3.862551e+00
R_6455_6456 6455 6456 1.551527e+00
R_6456_6457 6456 6457 5.148155e+00
R_6457_6458 6457 6458 1.099952e+00
R_6458_6459 6458 6459 6.372572e+00
R_6459_6460 6459 6460 6.734042e+00
R_6460_6461 6460 6461 1.065012e+00
R_6461_6462 6461 6462 5.822281e+00
R_6462_6463 6462 6463 1.400050e+00
R_6463_6464 6463 6464 8.480844e+00
R_6464_6465 6464 6465 9.405005e-01
R_6465_6466 6465 6466 3.688325e+00
R_6466_6467 6466 6467 4.571377e-01
R_6467_6468 6467 6468 9.700612e+00
R_6468_6469 6468 6469 3.497658e+00
R_6469_6470 6469 6470 3.418931e+00
R_6470_6471 6470 6471 7.586798e-01
R_6471_6472 6471 6472 9.610555e+00
R_6472_6473 6472 6473 6.873235e+00
R_6473_6474 6473 6474 6.771640e+00
R_6474_6475 6474 6475 8.558616e+00
R_6475_6476 6475 6476 5.227092e-01
R_6476_6477 6476 6477 7.372822e+00
R_6477_6478 6477 6478 6.845915e+00
R_6478_6479 6478 6479 8.615627e+00
R_6479_6480 6479 6480 1.436380e-02
R_6480_6481 6480 6481 6.905076e-01
R_6481_6482 6481 6482 7.086347e+00
R_6482_6483 6482 6483 3.698629e+00
R_6483_6484 6483 6484 3.145369e+00
R_6484_6485 6484 6485 7.488227e+00
R_6485_6486 6485 6486 8.284561e+00
R_6486_6487 6486 6487 3.028734e+00
R_6487_6488 6487 6488 4.172808e+00
R_6488_6489 6488 6489 1.452012e-01
R_6489_6490 6489 6490 3.603327e+00
R_6490_6491 6490 6491 2.770702e+00
R_6491_6492 6491 6492 2.279919e+00
R_6492_6493 6492 6493 1.891065e+00
R_6493_6494 6493 6494 1.826201e-01
R_6494_6495 6494 6495 2.703216e+00
R_6495_6496 6495 6496 8.960929e+00
R_6496_6497 6496 6497 5.743234e+00
R_6497_6498 6497 6498 1.219463e+00
R_6498_6499 6498 6499 4.399860e-01
R_6499_6500 6499 6500 7.537388e+00
R_6501_6502 6501 6502 7.921518e+00
R_6502_6503 6502 6503 5.927959e+00
R_6503_6504 6503 6504 2.392336e+00
R_6504_6505 6504 6505 6.038674e+00
R_6505_6506 6505 6506 5.531901e+00
R_6506_6507 6506 6507 1.871017e+00
R_6507_6508 6507 6508 1.825225e+00
R_6508_6509 6508 6509 6.794980e+00
R_6509_6510 6509 6510 3.710889e+00
R_6510_6511 6510 6511 7.720509e+00
R_6511_6512 6511 6512 7.255280e+00
R_6512_6513 6512 6513 2.822588e-01
R_6513_6514 6513 6514 9.033808e+00
R_6514_6515 6514 6515 8.430328e+00
R_6515_6516 6515 6516 7.726571e+00
R_6516_6517 6516 6517 2.663807e+00
R_6517_6518 6517 6518 7.921454e-01
R_6518_6519 6518 6519 2.361749e+00
R_6519_6520 6519 6520 9.822595e-01
R_6520_6521 6520 6521 4.655678e+00
R_6521_6522 6521 6522 4.463009e+00
R_6522_6523 6522 6523 3.467675e+00
R_6523_6524 6523 6524 4.999440e+00
R_6524_6525 6524 6525 6.187066e+00
R_6525_6526 6525 6526 6.834023e+00
R_6526_6527 6526 6527 2.393760e-01
R_6527_6528 6527 6528 2.669878e-01
R_6528_6529 6528 6529 2.626845e+00
R_6529_6530 6529 6530 3.449284e+00
R_6530_6531 6530 6531 4.904656e-01
R_6531_6532 6531 6532 1.616473e+00
R_6532_6533 6532 6533 8.571779e+00
R_6533_6534 6533 6534 1.749385e+00
R_6534_6535 6534 6535 3.612315e+00
R_6535_6536 6535 6536 8.344667e+00
R_6536_6537 6536 6537 3.665006e+00
R_6537_6538 6537 6538 1.975037e+00
R_6538_6539 6538 6539 5.242728e-01
R_6539_6540 6539 6540 8.702006e+00
R_6540_6541 6540 6541 9.882462e-01
R_6541_6542 6541 6542 4.849897e+00
R_6542_6543 6542 6543 4.500785e+00
R_6543_6544 6543 6544 1.436367e+00
R_6544_6545 6544 6545 4.575859e+00
R_6545_6546 6545 6546 8.317142e+00
R_6546_6547 6546 6547 8.966253e+00
R_6547_6548 6547 6548 2.993302e+00
R_6548_6549 6548 6549 1.473675e+00
R_6549_6550 6549 6550 2.468180e+00
R_6550_6551 6550 6551 8.967545e+00
R_6551_6552 6551 6552 9.282712e+00
R_6552_6553 6552 6553 1.739841e+00
R_6553_6554 6553 6554 3.177017e+00
R_6554_6555 6554 6555 9.161136e+00
R_6555_6556 6555 6556 3.286664e+00
R_6556_6557 6556 6557 2.843302e+00
R_6557_6558 6557 6558 4.195389e+00
R_6558_6559 6558 6559 5.521250e+00
R_6559_6560 6559 6560 1.062136e+00
R_6560_6561 6560 6561 3.701043e+00
R_6561_6562 6561 6562 6.776706e+00
R_6562_6563 6562 6563 1.035695e+00
R_6563_6564 6563 6564 4.006761e+00
R_6564_6565 6564 6565 1.940391e+00
R_6565_6566 6565 6566 9.893960e+00
R_6566_6567 6566 6567 4.600706e+00
R_6567_6568 6567 6568 2.499243e+00
R_6568_6569 6568 6569 5.459070e+00
R_6569_6570 6569 6570 5.850721e+00
R_6570_6571 6570 6571 6.015268e+00
R_6571_6572 6571 6572 7.938205e+00
R_6572_6573 6572 6573 4.244678e+00
R_6573_6574 6573 6574 1.452087e+00
R_6574_6575 6574 6575 8.297575e-01
R_6575_6576 6575 6576 7.303890e+00
R_6576_6577 6576 6577 5.300702e-01
R_6577_6578 6577 6578 7.438475e+00
R_6578_6579 6578 6579 3.084446e+00
R_6579_6580 6579 6580 2.392389e+00
R_6580_6581 6580 6581 7.783158e-01
R_6581_6582 6581 6582 1.023407e+00
R_6582_6583 6582 6583 3.290580e+00
R_6583_6584 6583 6584 7.179472e-01
R_6584_6585 6584 6585 9.087392e+00
R_6585_6586 6585 6586 1.583569e+00
R_6586_6587 6586 6587 9.272290e+00
R_6587_6588 6587 6588 1.794860e+00
R_6588_6589 6588 6589 6.563763e-01
R_6589_6590 6589 6590 2.054703e+00
R_6590_6591 6590 6591 9.539498e+00
R_6591_6592 6591 6592 8.248674e+00
R_6592_6593 6592 6593 2.509475e+00
R_6593_6594 6593 6594 1.012706e+00
R_6594_6595 6594 6595 7.760146e+00
R_6595_6596 6595 6596 8.773607e+00
R_6596_6597 6596 6597 4.420937e+00
R_6597_6598 6597 6598 2.661918e-01
R_6598_6599 6598 6599 4.370825e-01
R_6599_6600 6599 6600 6.105783e+00
R_6601_6602 6601 6602 3.438719e+00
R_6602_6603 6602 6603 8.750829e+00
R_6603_6604 6603 6604 2.781137e+00
R_6604_6605 6604 6605 3.491739e+00
R_6605_6606 6605 6606 7.646757e+00
R_6606_6607 6606 6607 7.257891e+00
R_6607_6608 6607 6608 4.022170e+00
R_6608_6609 6608 6609 3.158600e-01
R_6609_6610 6609 6610 9.301889e+00
R_6610_6611 6610 6611 9.840153e+00
R_6611_6612 6611 6612 9.712433e+00
R_6612_6613 6612 6613 9.325950e+00
R_6613_6614 6613 6614 4.751529e+00
R_6614_6615 6614 6615 3.248954e+00
R_6615_6616 6615 6616 2.930051e+00
R_6616_6617 6616 6617 4.897788e+00
R_6617_6618 6617 6618 5.591413e+00
R_6618_6619 6618 6619 2.647661e+00
R_6619_6620 6619 6620 9.641565e+00
R_6620_6621 6620 6621 8.754077e+00
R_6621_6622 6621 6622 2.113186e-01
R_6622_6623 6622 6623 5.443224e+00
R_6623_6624 6623 6624 6.862155e+00
R_6624_6625 6624 6625 7.162632e+00
R_6625_6626 6625 6626 6.241474e+00
R_6626_6627 6626 6627 8.974203e+00
R_6627_6628 6627 6628 5.350239e+00
R_6628_6629 6628 6629 6.965322e+00
R_6629_6630 6629 6630 5.538227e+00
R_6630_6631 6630 6631 3.599950e+00
R_6631_6632 6631 6632 1.184543e+00
R_6632_6633 6632 6633 3.203824e+00
R_6633_6634 6633 6634 5.115675e+00
R_6634_6635 6634 6635 3.276934e+00
R_6635_6636 6635 6636 2.141173e-01
R_6636_6637 6636 6637 4.180342e+00
R_6637_6638 6637 6638 9.582039e+00
R_6638_6639 6638 6639 6.880552e-01
R_6639_6640 6639 6640 6.378282e+00
R_6640_6641 6640 6641 1.551470e+00
R_6641_6642 6641 6642 6.504811e+00
R_6642_6643 6642 6643 7.064057e-01
R_6643_6644 6643 6644 3.626504e+00
R_6644_6645 6644 6645 8.955005e+00
R_6645_6646 6645 6646 3.319413e+00
R_6646_6647 6646 6647 1.517472e-01
R_6647_6648 6647 6648 7.101706e-01
R_6648_6649 6648 6649 9.187684e+00
R_6649_6650 6649 6650 2.293502e+00
R_6650_6651 6650 6651 9.786598e+00
R_6651_6652 6651 6652 6.425745e+00
R_6652_6653 6652 6653 5.304807e+00
R_6653_6654 6653 6654 1.592564e+00
R_6654_6655 6654 6655 7.240614e+00
R_6655_6656 6655 6656 2.411113e+00
R_6656_6657 6656 6657 4.309182e+00
R_6657_6658 6657 6658 8.064014e+00
R_6658_6659 6658 6659 9.902832e+00
R_6659_6660 6659 6660 9.055908e+00
R_6660_6661 6660 6661 8.807676e-01
R_6661_6662 6661 6662 5.306510e+00
R_6662_6663 6662 6663 2.310994e+00
R_6663_6664 6663 6664 7.618256e+00
R_6664_6665 6664 6665 5.709697e+00
R_6665_6666 6665 6666 8.482299e-01
R_6666_6667 6666 6667 9.163739e+00
R_6667_6668 6667 6668 1.172907e+00
R_6668_6669 6668 6669 9.958916e+00
R_6669_6670 6669 6670 1.627562e-01
R_6670_6671 6670 6671 8.367179e+00
R_6671_6672 6671 6672 7.961652e+00
R_6672_6673 6672 6673 8.860114e+00
R_6673_6674 6673 6674 1.015590e+00
R_6674_6675 6674 6675 9.011040e+00
R_6675_6676 6675 6676 7.896336e+00
R_6676_6677 6676 6677 3.885120e+00
R_6677_6678 6677 6678 5.730310e+00
R_6678_6679 6678 6679 8.566366e+00
R_6679_6680 6679 6680 4.374022e+00
R_6680_6681 6680 6681 2.502692e+00
R_6681_6682 6681 6682 4.029388e+00
R_6682_6683 6682 6683 4.054733e+00
R_6683_6684 6683 6684 3.431843e+00
R_6684_6685 6684 6685 4.103278e-01
R_6685_6686 6685 6686 1.006276e+00
R_6686_6687 6686 6687 1.712993e+00
R_6687_6688 6687 6688 3.294379e+00
R_6688_6689 6688 6689 2.713548e+00
R_6689_6690 6689 6690 8.208952e+00
R_6690_6691 6690 6691 7.618224e+00
R_6691_6692 6691 6692 3.208259e+00
R_6692_6693 6692 6693 2.576486e+00
R_6693_6694 6693 6694 5.702989e+00
R_6694_6695 6694 6695 3.786577e+00
R_6695_6696 6695 6696 4.015920e+00
R_6696_6697 6696 6697 2.049661e+00
R_6697_6698 6697 6698 7.819029e+00
R_6698_6699 6698 6699 9.126860e+00
R_6699_6700 6699 6700 8.750406e+00
R_6701_6702 6701 6702 7.609012e+00
R_6702_6703 6702 6703 3.598260e+00
R_6703_6704 6703 6704 6.303399e+00
R_6704_6705 6704 6705 2.741616e+00
R_6705_6706 6705 6706 3.810630e+00
R_6706_6707 6706 6707 4.013843e+00
R_6707_6708 6707 6708 6.783631e+00
R_6708_6709 6708 6709 5.882713e+00
R_6709_6710 6709 6710 9.434544e+00
R_6710_6711 6710 6711 7.094996e-01
R_6711_6712 6711 6712 1.639378e+00
R_6712_6713 6712 6713 3.886546e+00
R_6713_6714 6713 6714 8.223648e+00
R_6714_6715 6714 6715 6.793179e+00
R_6715_6716 6715 6716 4.646809e+00
R_6716_6717 6716 6717 1.863381e+00
R_6717_6718 6717 6718 5.823056e+00
R_6718_6719 6718 6719 1.071577e+00
R_6719_6720 6719 6720 7.291557e+00
R_6720_6721 6720 6721 6.010986e+00
R_6721_6722 6721 6722 2.777374e+00
R_6722_6723 6722 6723 1.690182e+00
R_6723_6724 6723 6724 5.992085e+00
R_6724_6725 6724 6725 3.629600e+00
R_6725_6726 6725 6726 7.135228e-01
R_6726_6727 6726 6727 7.295585e+00
R_6727_6728 6727 6728 9.203144e+00
R_6728_6729 6728 6729 7.015427e+00
R_6729_6730 6729 6730 1.888311e+00
R_6730_6731 6730 6731 4.551451e-01
R_6731_6732 6731 6732 1.325731e+00
R_6732_6733 6732 6733 6.109851e+00
R_6733_6734 6733 6734 2.493741e+00
R_6734_6735 6734 6735 8.719113e-02
R_6735_6736 6735 6736 3.505387e+00
R_6736_6737 6736 6737 7.361570e+00
R_6737_6738 6737 6738 5.237768e+00
R_6738_6739 6738 6739 5.657841e+00
R_6739_6740 6739 6740 6.634725e+00
R_6740_6741 6740 6741 5.442608e+00
R_6741_6742 6741 6742 9.015936e+00
R_6742_6743 6742 6743 4.495098e+00
R_6743_6744 6743 6744 9.032847e+00
R_6744_6745 6744 6745 2.525050e+00
R_6745_6746 6745 6746 7.489393e+00
R_6746_6747 6746 6747 8.622256e-01
R_6747_6748 6747 6748 7.288657e+00
R_6748_6749 6748 6749 8.454004e+00
R_6749_6750 6749 6750 4.363243e+00
R_6750_6751 6750 6751 9.053015e+00
R_6751_6752 6751 6752 4.818249e+00
R_6752_6753 6752 6753 6.390718e+00
R_6753_6754 6753 6754 9.463335e+00
R_6754_6755 6754 6755 4.024126e-01
R_6755_6756 6755 6756 3.100060e+00
R_6756_6757 6756 6757 5.138113e+00
R_6757_6758 6757 6758 4.818243e+00
R_6758_6759 6758 6759 8.590440e+00
R_6759_6760 6759 6760 2.458135e+00
R_6760_6761 6760 6761 5.492844e+00
R_6761_6762 6761 6762 4.312156e+00
R_6762_6763 6762 6763 7.875120e+00
R_6763_6764 6763 6764 5.985718e+00
R_6764_6765 6764 6765 1.389381e+00
R_6765_6766 6765 6766 7.227463e+00
R_6766_6767 6766 6767 9.306100e+00
R_6767_6768 6767 6768 8.929687e+00
R_6768_6769 6768 6769 1.419955e+00
R_6769_6770 6769 6770 7.612295e+00
R_6770_6771 6770 6771 3.212895e+00
R_6771_6772 6771 6772 3.118800e+00
R_6772_6773 6772 6773 7.868137e+00
R_6773_6774 6773 6774 7.702961e+00
R_6774_6775 6774 6775 4.148456e+00
R_6775_6776 6775 6776 4.601801e+00
R_6776_6777 6776 6777 1.359713e+00
R_6777_6778 6777 6778 1.928650e+00
R_6778_6779 6778 6779 8.504106e+00
R_6779_6780 6779 6780 6.992801e+00
R_6780_6781 6780 6781 9.054040e+00
R_6781_6782 6781 6782 2.221285e+00
R_6782_6783 6782 6783 2.894518e+00
R_6783_6784 6783 6784 1.449109e+00
R_6784_6785 6784 6785 5.830419e+00
R_6785_6786 6785 6786 7.822846e+00
R_6786_6787 6786 6787 7.151256e+00
R_6787_6788 6787 6788 8.977608e+00
R_6788_6789 6788 6789 4.112171e+00
R_6789_6790 6789 6790 9.333976e+00
R_6790_6791 6790 6791 9.175684e+00
R_6791_6792 6791 6792 2.701568e+00
R_6792_6793 6792 6793 8.584488e+00
R_6793_6794 6793 6794 2.559375e+00
R_6794_6795 6794 6795 1.479770e+00
R_6795_6796 6795 6796 8.334867e+00
R_6796_6797 6796 6797 7.062668e+00
R_6797_6798 6797 6798 1.793929e+00
R_6798_6799 6798 6799 3.719005e+00
R_6799_6800 6799 6800 4.078390e+00
R_6801_6802 6801 6802 1.019868e+00
R_6802_6803 6802 6803 8.440583e-01
R_6803_6804 6803 6804 8.646336e+00
R_6804_6805 6804 6805 9.666876e+00
R_6805_6806 6805 6806 3.590153e-01
R_6806_6807 6806 6807 4.278974e-02
R_6807_6808 6807 6808 9.419759e-02
R_6808_6809 6808 6809 1.858998e-01
R_6809_6810 6809 6810 8.026945e+00
R_6810_6811 6810 6811 4.264098e+00
R_6811_6812 6811 6812 4.995448e+00
R_6812_6813 6812 6813 3.646257e+00
R_6813_6814 6813 6814 2.626231e+00
R_6814_6815 6814 6815 3.588071e+00
R_6815_6816 6815 6816 3.541361e-01
R_6816_6817 6816 6817 2.062886e+00
R_6817_6818 6817 6818 9.248556e+00
R_6818_6819 6818 6819 3.311782e+00
R_6819_6820 6819 6820 7.404289e+00
R_6820_6821 6820 6821 7.799225e+00
R_6821_6822 6821 6822 5.406797e+00
R_6822_6823 6822 6823 5.329524e+00
R_6823_6824 6823 6824 6.515404e+00
R_6824_6825 6824 6825 3.674016e+00
R_6825_6826 6825 6826 6.944743e+00
R_6826_6827 6826 6827 1.807489e+00
R_6827_6828 6827 6828 3.987557e+00
R_6828_6829 6828 6829 2.530318e-01
R_6829_6830 6829 6830 2.438795e+00
R_6830_6831 6830 6831 4.785356e+00
R_6831_6832 6831 6832 4.994568e+00
R_6832_6833 6832 6833 7.610366e+00
R_6833_6834 6833 6834 9.940318e+00
R_6834_6835 6834 6835 4.649014e+00
R_6835_6836 6835 6836 1.919981e+00
R_6836_6837 6836 6837 7.490267e+00
R_6837_6838 6837 6838 3.947609e+00
R_6838_6839 6838 6839 3.782658e+00
R_6839_6840 6839 6840 6.979670e+00
R_6840_6841 6840 6841 9.116842e+00
R_6841_6842 6841 6842 1.211124e+00
R_6842_6843 6842 6843 9.634523e+00
R_6843_6844 6843 6844 7.229721e+00
R_6844_6845 6844 6845 3.895891e+00
R_6845_6846 6845 6846 4.298858e+00
R_6846_6847 6846 6847 9.225934e-01
R_6847_6848 6847 6848 6.816734e+00
R_6848_6849 6848 6849 7.122797e+00
R_6849_6850 6849 6850 6.833872e+00
R_6850_6851 6850 6851 9.401365e+00
R_6851_6852 6851 6852 1.380484e+00
R_6852_6853 6852 6853 2.674655e+00
R_6853_6854 6853 6854 9.727103e+00
R_6854_6855 6854 6855 7.490017e+00
R_6855_6856 6855 6856 8.162094e+00
R_6856_6857 6856 6857 4.799617e+00
R_6857_6858 6857 6858 4.569366e+00
R_6858_6859 6858 6859 3.949815e+00
R_6859_6860 6859 6860 4.656079e+00
R_6860_6861 6860 6861 5.036129e+00
R_6861_6862 6861 6862 4.086565e+00
R_6862_6863 6862 6863 3.020098e+00
R_6863_6864 6863 6864 7.106100e-01
R_6864_6865 6864 6865 7.804395e+00
R_6865_6866 6865 6866 8.684413e+00
R_6866_6867 6866 6867 6.394452e+00
R_6867_6868 6867 6868 2.833893e+00
R_6868_6869 6868 6869 2.128748e+00
R_6869_6870 6869 6870 8.936509e+00
R_6870_6871 6870 6871 9.552745e+00
R_6871_6872 6871 6872 6.204250e+00
R_6872_6873 6872 6873 9.750019e+00
R_6873_6874 6873 6874 5.661959e+00
R_6874_6875 6874 6875 3.172287e-01
R_6875_6876 6875 6876 7.814001e+00
R_6876_6877 6876 6877 3.781750e+00
R_6877_6878 6877 6878 1.013846e+00
R_6878_6879 6878 6879 7.808644e+00
R_6879_6880 6879 6880 9.962380e+00
R_6880_6881 6880 6881 8.914608e+00
R_6881_6882 6881 6882 5.519331e+00
R_6882_6883 6882 6883 2.705258e+00
R_6883_6884 6883 6884 8.271436e+00
R_6884_6885 6884 6885 9.247478e+00
R_6885_6886 6885 6886 3.677434e+00
R_6886_6887 6886 6887 6.754461e+00
R_6887_6888 6887 6888 9.751739e+00
R_6888_6889 6888 6889 7.275045e+00
R_6889_6890 6889 6890 1.628940e-01
R_6890_6891 6890 6891 7.176096e+00
R_6891_6892 6891 6892 9.813442e+00
R_6892_6893 6892 6893 1.770574e+00
R_6893_6894 6893 6894 3.305602e+00
R_6894_6895 6894 6895 2.079963e+00
R_6895_6896 6895 6896 6.097270e+00
R_6896_6897 6896 6897 9.934876e-01
R_6897_6898 6897 6898 6.408290e+00
R_6898_6899 6898 6899 2.967436e+00
R_6899_6900 6899 6900 1.388439e+00
R_6901_6902 6901 6902 8.350642e+00
R_6902_6903 6902 6903 7.600961e+00
R_6903_6904 6903 6904 5.559688e+00
R_6904_6905 6904 6905 1.656859e+00
R_6905_6906 6905 6906 4.353806e-01
R_6906_6907 6906 6907 9.118499e+00
R_6907_6908 6907 6908 1.654005e+00
R_6908_6909 6908 6909 5.210301e+00
R_6909_6910 6909 6910 4.964181e+00
R_6910_6911 6910 6911 5.034765e+00
R_6911_6912 6911 6912 1.712634e+00
R_6912_6913 6912 6913 4.158764e+00
R_6913_6914 6913 6914 3.247674e+00
R_6914_6915 6914 6915 8.544304e-01
R_6915_6916 6915 6916 5.862659e+00
R_6916_6917 6916 6917 7.593430e-01
R_6917_6918 6917 6918 3.400108e+00
R_6918_6919 6918 6919 6.911584e+00
R_6919_6920 6919 6920 9.236704e+00
R_6920_6921 6920 6921 7.791513e+00
R_6921_6922 6921 6922 2.229042e-01
R_6922_6923 6922 6923 1.219145e+00
R_6923_6924 6923 6924 2.300021e+00
R_6924_6925 6924 6925 8.609858e+00
R_6925_6926 6925 6926 6.686928e+00
R_6926_6927 6926 6927 5.200347e+00
R_6927_6928 6927 6928 4.020186e+00
R_6928_6929 6928 6929 6.441489e+00
R_6929_6930 6929 6930 1.811049e+00
R_6930_6931 6930 6931 7.260421e+00
R_6931_6932 6931 6932 3.910579e+00
R_6932_6933 6932 6933 1.552717e+00
R_6933_6934 6933 6934 8.226065e+00
R_6934_6935 6934 6935 1.381538e+00
R_6935_6936 6935 6936 9.160707e+00
R_6936_6937 6936 6937 8.122085e+00
R_6937_6938 6937 6938 5.569223e+00
R_6938_6939 6938 6939 6.634764e+00
R_6939_6940 6939 6940 1.940289e+00
R_6940_6941 6940 6941 1.755301e-01
R_6941_6942 6941 6942 6.152423e+00
R_6942_6943 6942 6943 4.506382e-01
R_6943_6944 6943 6944 3.548081e+00
R_6944_6945 6944 6945 7.451463e+00
R_6945_6946 6945 6946 3.207304e+00
R_6946_6947 6946 6947 7.539137e+00
R_6947_6948 6947 6948 9.716258e+00
R_6948_6949 6948 6949 4.633289e-01
R_6949_6950 6949 6950 4.258566e+00
R_6950_6951 6950 6951 8.107319e+00
R_6951_6952 6951 6952 4.683141e+00
R_6952_6953 6952 6953 5.943255e+00
R_6953_6954 6953 6954 2.694013e-01
R_6954_6955 6954 6955 9.683977e+00
R_6955_6956 6955 6956 5.456229e+00
R_6956_6957 6956 6957 4.884595e-01
R_6957_6958 6957 6958 6.769772e+00
R_6958_6959 6958 6959 3.688997e+00
R_6959_6960 6959 6960 5.884446e+00
R_6960_6961 6960 6961 6.202048e+00
R_6961_6962 6961 6962 7.258867e+00
R_6962_6963 6962 6963 3.295714e+00
R_6963_6964 6963 6964 9.363405e+00
R_6964_6965 6964 6965 9.221190e+00
R_6965_6966 6965 6966 1.546383e+00
R_6966_6967 6966 6967 8.994895e+00
R_6967_6968 6967 6968 5.966656e+00
R_6968_6969 6968 6969 8.871824e+00
R_6969_6970 6969 6970 5.871975e+00
R_6970_6971 6970 6971 6.076797e+00
R_6971_6972 6971 6972 7.149818e+00
R_6972_6973 6972 6973 2.275276e+00
R_6973_6974 6973 6974 9.313799e+00
R_6974_6975 6974 6975 5.676361e+00
R_6975_6976 6975 6976 9.854187e+00
R_6976_6977 6976 6977 9.501824e+00
R_6977_6978 6977 6978 5.100983e+00
R_6978_6979 6978 6979 2.766371e+00
R_6979_6980 6979 6980 6.980985e+00
R_6980_6981 6980 6981 3.058996e+00
R_6981_6982 6981 6982 8.350129e-01
R_6982_6983 6982 6983 5.130482e+00
R_6983_6984 6983 6984 9.414378e+00
R_6984_6985 6984 6985 9.986624e-01
R_6985_6986 6985 6986 3.157173e+00
R_6986_6987 6986 6987 6.006774e+00
R_6987_6988 6987 6988 6.799746e+00
R_6988_6989 6988 6989 9.795710e+00
R_6989_6990 6989 6990 4.202035e+00
R_6990_6991 6990 6991 6.131681e-02
R_6991_6992 6991 6992 3.884845e+00
R_6992_6993 6992 6993 1.953057e+00
R_6993_6994 6993 6994 5.552119e-01
R_6994_6995 6994 6995 9.235573e+00
R_6995_6996 6995 6996 3.319951e+00
R_6996_6997 6996 6997 1.758735e+00
R_6997_6998 6997 6998 9.425144e+00
R_6998_6999 6998 6999 3.369556e+00
R_6999_7000 6999 7000 1.907968e+00
R_7001_7002 7001 7002 1.016749e+00
R_7002_7003 7002 7003 1.747795e+00
R_7003_7004 7003 7004 8.037734e+00
R_7004_7005 7004 7005 3.477071e+00
R_7005_7006 7005 7006 5.153439e+00
R_7006_7007 7006 7007 5.306146e+00
R_7007_7008 7007 7008 6.511680e+00
R_7008_7009 7008 7009 6.243510e+00
R_7009_7010 7009 7010 1.965589e+00
R_7010_7011 7010 7011 4.832975e+00
R_7011_7012 7011 7012 4.160572e-01
R_7012_7013 7012 7013 3.753126e+00
R_7013_7014 7013 7014 2.747093e-01
R_7014_7015 7014 7015 5.334821e+00
R_7015_7016 7015 7016 8.080017e+00
R_7016_7017 7016 7017 1.406584e+00
R_7017_7018 7017 7018 9.014076e+00
R_7018_7019 7018 7019 3.510864e+00
R_7019_7020 7019 7020 2.374991e+00
R_7020_7021 7020 7021 6.762807e-01
R_7021_7022 7021 7022 7.476695e+00
R_7022_7023 7022 7023 7.699845e+00
R_7023_7024 7023 7024 4.502874e+00
R_7024_7025 7024 7025 2.378103e+00
R_7025_7026 7025 7026 3.917555e+00
R_7026_7027 7026 7027 8.575120e+00
R_7027_7028 7027 7028 3.655140e+00
R_7028_7029 7028 7029 4.728968e+00
R_7029_7030 7029 7030 8.443644e-01
R_7030_7031 7030 7031 6.801282e-02
R_7031_7032 7031 7032 8.627773e+00
R_7032_7033 7032 7033 9.702946e+00
R_7033_7034 7033 7034 7.350023e+00
R_7034_7035 7034 7035 1.205439e+00
R_7035_7036 7035 7036 2.171650e-01
R_7036_7037 7036 7037 2.276326e+00
R_7037_7038 7037 7038 1.905582e+00
R_7038_7039 7038 7039 8.010700e+00
R_7039_7040 7039 7040 1.628550e+00
R_7040_7041 7040 7041 8.674262e-01
R_7041_7042 7041 7042 4.955977e+00
R_7042_7043 7042 7043 9.278779e-01
R_7043_7044 7043 7044 1.668096e+00
R_7044_7045 7044 7045 1.529793e+00
R_7045_7046 7045 7046 6.340637e+00
R_7046_7047 7046 7047 6.062143e+00
R_7047_7048 7047 7048 8.188687e-01
R_7048_7049 7048 7049 5.395090e+00
R_7049_7050 7049 7050 6.344720e+00
R_7050_7051 7050 7051 3.313434e-01
R_7051_7052 7051 7052 2.838062e-01
R_7052_7053 7052 7053 2.131979e-01
R_7053_7054 7053 7054 1.364908e+00
R_7054_7055 7054 7055 4.054753e+00
R_7055_7056 7055 7056 4.716113e-01
R_7056_7057 7056 7057 2.528689e+00
R_7057_7058 7057 7058 8.775203e+00
R_7058_7059 7058 7059 6.729048e+00
R_7059_7060 7059 7060 9.241029e+00
R_7060_7061 7060 7061 9.877276e+00
R_7061_7062 7061 7062 5.661289e+00
R_7062_7063 7062 7063 4.797132e+00
R_7063_7064 7063 7064 3.225712e+00
R_7064_7065 7064 7065 1.052887e+00
R_7065_7066 7065 7066 2.924546e+00
R_7066_7067 7066 7067 1.784512e+00
R_7067_7068 7067 7068 9.203780e+00
R_7068_7069 7068 7069 3.900616e+00
R_7069_7070 7069 7070 9.392260e+00
R_7070_7071 7070 7071 1.048355e+00
R_7071_7072 7071 7072 6.134802e+00
R_7072_7073 7072 7073 7.179497e+00
R_7073_7074 7073 7074 1.323537e+00
R_7074_7075 7074 7075 6.961454e+00
R_7075_7076 7075 7076 2.710737e-01
R_7076_7077 7076 7077 3.521775e+00
R_7077_7078 7077 7078 4.826172e-01
R_7078_7079 7078 7079 9.711021e+00
R_7079_7080 7079 7080 2.680280e+00
R_7080_7081 7080 7081 9.762383e+00
R_7081_7082 7081 7082 4.876565e+00
R_7082_7083 7082 7083 4.886229e+00
R_7083_7084 7083 7084 4.914178e+00
R_7084_7085 7084 7085 7.835058e+00
R_7085_7086 7085 7086 9.513174e+00
R_7086_7087 7086 7087 4.792058e+00
R_7087_7088 7087 7088 3.513458e+00
R_7088_7089 7088 7089 4.983598e+00
R_7089_7090 7089 7090 7.774031e+00
R_7090_7091 7090 7091 4.315038e+00
R_7091_7092 7091 7092 6.424963e+00
R_7092_7093 7092 7093 4.089099e+00
R_7093_7094 7093 7094 8.223470e+00
R_7094_7095 7094 7095 3.734918e+00
R_7095_7096 7095 7096 5.897751e+00
R_7096_7097 7096 7097 2.864207e+00
R_7097_7098 7097 7098 4.433047e+00
R_7098_7099 7098 7099 2.303960e+00
R_7099_7100 7099 7100 4.843473e+00
R_7101_7102 7101 7102 4.332644e+00
R_7102_7103 7102 7103 3.846438e+00
R_7103_7104 7103 7104 5.074557e+00
R_7104_7105 7104 7105 5.705102e+00
R_7105_7106 7105 7106 4.584812e+00
R_7106_7107 7106 7107 7.255069e+00
R_7107_7108 7107 7108 1.622447e+00
R_7108_7109 7108 7109 4.722659e-01
R_7109_7110 7109 7110 6.670147e+00
R_7110_7111 7110 7111 9.529932e+00
R_7111_7112 7111 7112 2.337237e+00
R_7112_7113 7112 7113 7.734623e+00
R_7113_7114 7113 7114 1.892168e+00
R_7114_7115 7114 7115 2.281114e+00
R_7115_7116 7115 7116 6.765053e+00
R_7116_7117 7116 7117 7.443703e+00
R_7117_7118 7117 7118 2.420226e+00
R_7118_7119 7118 7119 5.177931e+00
R_7119_7120 7119 7120 5.064068e+00
R_7120_7121 7120 7121 8.836111e+00
R_7121_7122 7121 7122 8.062115e+00
R_7122_7123 7122 7123 2.727767e+00
R_7123_7124 7123 7124 6.143652e+00
R_7124_7125 7124 7125 9.302825e+00
R_7125_7126 7125 7126 3.359660e-02
R_7126_7127 7126 7127 3.914419e+00
R_7127_7128 7127 7128 9.408414e-02
R_7128_7129 7128 7129 4.158041e+00
R_7129_7130 7129 7130 5.772163e+00
R_7130_7131 7130 7131 1.859004e+00
R_7131_7132 7131 7132 2.935808e+00
R_7132_7133 7132 7133 9.918166e+00
R_7133_7134 7133 7134 7.131777e+00
R_7134_7135 7134 7135 4.156709e+00
R_7135_7136 7135 7136 8.399587e+00
R_7136_7137 7136 7137 5.809880e+00
R_7137_7138 7137 7138 8.981544e-01
R_7138_7139 7138 7139 1.954062e+00
R_7139_7140 7139 7140 7.414912e+00
R_7140_7141 7140 7141 7.915887e+00
R_7141_7142 7141 7142 4.000644e+00
R_7142_7143 7142 7143 4.323164e+00
R_7143_7144 7143 7144 3.487047e+00
R_7144_7145 7144 7145 5.779212e+00
R_7145_7146 7145 7146 5.090787e+00
R_7146_7147 7146 7147 2.459784e+00
R_7147_7148 7147 7148 8.581186e+00
R_7148_7149 7148 7149 8.988715e-01
R_7149_7150 7149 7150 8.015386e+00
R_7150_7151 7150 7151 6.228880e+00
R_7151_7152 7151 7152 4.673950e+00
R_7152_7153 7152 7153 6.115818e+00
R_7153_7154 7153 7154 4.971892e+00
R_7154_7155 7154 7155 8.761785e+00
R_7155_7156 7155 7156 6.614880e+00
R_7156_7157 7156 7157 2.536557e+00
R_7157_7158 7157 7158 4.091659e+00
R_7158_7159 7158 7159 8.074571e+00
R_7159_7160 7159 7160 5.324884e+00
R_7160_7161 7160 7161 4.820086e-01
R_7161_7162 7161 7162 2.781896e+00
R_7162_7163 7162 7163 7.406220e+00
R_7163_7164 7163 7164 4.582821e+00
R_7164_7165 7164 7165 9.840301e+00
R_7165_7166 7165 7166 8.913895e+00
R_7166_7167 7166 7167 8.658224e+00
R_7167_7168 7167 7168 5.210837e+00
R_7168_7169 7168 7169 9.168683e+00
R_7169_7170 7169 7170 4.741430e+00
R_7170_7171 7170 7171 5.669153e+00
R_7171_7172 7171 7172 4.989791e+00
R_7172_7173 7172 7173 2.762946e+00
R_7173_7174 7173 7174 4.155130e+00
R_7174_7175 7174 7175 6.667384e+00
R_7175_7176 7175 7176 2.065330e+00
R_7176_7177 7176 7177 6.538970e+00
R_7177_7178 7177 7178 1.031233e+00
R_7178_7179 7178 7179 1.616091e+00
R_7179_7180 7179 7180 8.627781e+00
R_7180_7181 7180 7181 4.578882e+00
R_7181_7182 7181 7182 7.201163e-01
R_7182_7183 7182 7183 5.471732e+00
R_7183_7184 7183 7184 7.277089e+00
R_7184_7185 7184 7185 9.839505e+00
R_7185_7186 7185 7186 8.701618e+00
R_7186_7187 7186 7187 8.055628e+00
R_7187_7188 7187 7188 2.405961e+00
R_7188_7189 7188 7189 9.876965e+00
R_7189_7190 7189 7190 1.999817e+00
R_7190_7191 7190 7191 8.576107e+00
R_7191_7192 7191 7192 7.471401e+00
R_7192_7193 7192 7193 4.293944e+00
R_7193_7194 7193 7194 3.032139e+00
R_7194_7195 7194 7195 8.676029e+00
R_7195_7196 7195 7196 1.517075e+00
R_7196_7197 7196 7197 1.335976e+00
R_7197_7198 7197 7198 9.254347e+00
R_7198_7199 7198 7199 2.060419e+00
R_7199_7200 7199 7200 1.815477e+00
R_7201_7202 7201 7202 2.807282e-01
R_7202_7203 7202 7203 7.157256e+00
R_7203_7204 7203 7204 4.640098e+00
R_7204_7205 7204 7205 5.746405e+00
R_7205_7206 7205 7206 7.129418e+00
R_7206_7207 7206 7207 9.050569e+00
R_7207_7208 7207 7208 5.723800e+00
R_7208_7209 7208 7209 7.374280e+00
R_7209_7210 7209 7210 4.265994e+00
R_7210_7211 7210 7211 2.727096e+00
R_7211_7212 7211 7212 3.184933e+00
R_7212_7213 7212 7213 4.583467e+00
R_7213_7214 7213 7214 2.489418e+00
R_7214_7215 7214 7215 4.721926e+00
R_7215_7216 7215 7216 2.326855e+00
R_7216_7217 7216 7217 1.514578e+00
R_7217_7218 7217 7218 5.287620e+00
R_7218_7219 7218 7219 4.982701e+00
R_7219_7220 7219 7220 2.771495e+00
R_7220_7221 7220 7221 9.906981e+00
R_7221_7222 7221 7222 5.804620e+00
R_7222_7223 7222 7223 1.783129e-01
R_7223_7224 7223 7224 2.022598e+00
R_7224_7225 7224 7225 8.206666e+00
R_7225_7226 7225 7226 7.450901e+00
R_7226_7227 7226 7227 4.697204e+00
R_7227_7228 7227 7228 1.248012e+00
R_7228_7229 7228 7229 7.879036e+00
R_7229_7230 7229 7230 4.249979e+00
R_7230_7231 7230 7231 8.280082e+00
R_7231_7232 7231 7232 8.191095e+00
R_7232_7233 7232 7233 2.728803e+00
R_7233_7234 7233 7234 9.278596e+00
R_7234_7235 7234 7235 5.840033e+00
R_7235_7236 7235 7236 3.669879e+00
R_7236_7237 7236 7237 9.406026e+00
R_7237_7238 7237 7238 6.691362e-01
R_7238_7239 7238 7239 7.253597e+00
R_7239_7240 7239 7240 1.932600e+00
R_7240_7241 7240 7241 4.976396e-02
R_7241_7242 7241 7242 6.650285e-01
R_7242_7243 7242 7243 4.378458e+00
R_7243_7244 7243 7244 3.884114e+00
R_7244_7245 7244 7245 3.872648e+00
R_7245_7246 7245 7246 2.959959e+00
R_7246_7247 7246 7247 4.523261e+00
R_7247_7248 7247 7248 8.048872e+00
R_7248_7249 7248 7249 7.391965e+00
R_7249_7250 7249 7250 6.067858e+00
R_7250_7251 7250 7251 8.111021e+00
R_7251_7252 7251 7252 4.569382e+00
R_7252_7253 7252 7253 2.432313e+00
R_7253_7254 7253 7254 1.383962e+00
R_7254_7255 7254 7255 2.739421e-01
R_7255_7256 7255 7256 3.374332e+00
R_7256_7257 7256 7257 9.020305e+00
R_7257_7258 7257 7258 2.793336e+00
R_7258_7259 7258 7259 2.241703e+00
R_7259_7260 7259 7260 7.015339e+00
R_7260_7261 7260 7261 1.333399e+00
R_7261_7262 7261 7262 4.103048e+00
R_7262_7263 7262 7263 7.194765e+00
R_7263_7264 7263 7264 1.378376e+00
R_7264_7265 7264 7265 1.950208e+00
R_7265_7266 7265 7266 9.324582e+00
R_7266_7267 7266 7267 5.818157e+00
R_7267_7268 7267 7268 6.805190e+00
R_7268_7269 7268 7269 2.425995e-01
R_7269_7270 7269 7270 5.636572e+00
R_7270_7271 7270 7271 1.990856e+00
R_7271_7272 7271 7272 8.374858e+00
R_7272_7273 7272 7273 1.416282e-01
R_7273_7274 7273 7274 8.128536e+00
R_7274_7275 7274 7275 9.297329e+00
R_7275_7276 7275 7276 4.841879e+00
R_7276_7277 7276 7277 5.081889e+00
R_7277_7278 7277 7278 5.548828e+00
R_7278_7279 7278 7279 1.542456e-01
R_7279_7280 7279 7280 4.303278e+00
R_7280_7281 7280 7281 8.149131e+00
R_7281_7282 7281 7282 4.151777e+00
R_7282_7283 7282 7283 7.505333e+00
R_7283_7284 7283 7284 8.698020e+00
R_7284_7285 7284 7285 2.822661e+00
R_7285_7286 7285 7286 5.273393e-01
R_7286_7287 7286 7287 3.198681e+00
R_7287_7288 7287 7288 5.600085e+00
R_7288_7289 7288 7289 6.458417e+00
R_7289_7290 7289 7290 7.411109e+00
R_7290_7291 7290 7291 1.589825e+00
R_7291_7292 7291 7292 3.985886e+00
R_7292_7293 7292 7293 2.466056e+00
R_7293_7294 7293 7294 7.735400e-01
R_7294_7295 7294 7295 2.673179e+00
R_7295_7296 7295 7296 7.417688e-02
R_7296_7297 7296 7297 5.645072e+00
R_7297_7298 7297 7298 9.460382e+00
R_7298_7299 7298 7299 6.720234e+00
R_7299_7300 7299 7300 5.414014e+00
R_7301_7302 7301 7302 7.842116e+00
R_7302_7303 7302 7303 2.212866e-02
R_7303_7304 7303 7304 8.578823e+00
R_7304_7305 7304 7305 9.639951e+00
R_7305_7306 7305 7306 9.336659e+00
R_7306_7307 7306 7307 5.598684e+00
R_7307_7308 7307 7308 7.384716e-01
R_7308_7309 7308 7309 2.589454e+00
R_7309_7310 7309 7310 5.476634e+00
R_7310_7311 7310 7311 7.688363e+00
R_7311_7312 7311 7312 3.121865e+00
R_7312_7313 7312 7313 9.108394e+00
R_7313_7314 7313 7314 2.868453e+00
R_7314_7315 7314 7315 9.143486e+00
R_7315_7316 7315 7316 3.180818e+00
R_7316_7317 7316 7317 6.248027e+00
R_7317_7318 7317 7318 2.672158e+00
R_7318_7319 7318 7319 8.750611e+00
R_7319_7320 7319 7320 4.734817e+00
R_7320_7321 7320 7321 4.295269e+00
R_7321_7322 7321 7322 8.859912e+00
R_7322_7323 7322 7323 7.697788e+00
R_7323_7324 7323 7324 1.591490e+00
R_7324_7325 7324 7325 8.894837e+00
R_7325_7326 7325 7326 9.754639e+00
R_7326_7327 7326 7327 4.196624e+00
R_7327_7328 7327 7328 3.772944e+00
R_7328_7329 7328 7329 6.327002e+00
R_7329_7330 7329 7330 2.093273e-01
R_7330_7331 7330 7331 7.005472e+00
R_7331_7332 7331 7332 5.368125e+00
R_7332_7333 7332 7333 9.245375e+00
R_7333_7334 7333 7334 1.156771e+00
R_7334_7335 7334 7335 1.044136e+00
R_7335_7336 7335 7336 1.628369e+00
R_7336_7337 7336 7337 5.820728e+00
R_7337_7338 7337 7338 7.254871e+00
R_7338_7339 7338 7339 7.604734e+00
R_7339_7340 7339 7340 9.061919e+00
R_7340_7341 7340 7341 2.945668e+00
R_7341_7342 7341 7342 6.860792e+00
R_7342_7343 7342 7343 3.278688e-01
R_7343_7344 7343 7344 7.982982e+00
R_7344_7345 7344 7345 4.798253e+00
R_7345_7346 7345 7346 4.443745e+00
R_7346_7347 7346 7347 5.709104e+00
R_7347_7348 7347 7348 7.416380e+00
R_7348_7349 7348 7349 9.563901e+00
R_7349_7350 7349 7350 3.727492e-01
R_7350_7351 7350 7351 4.170981e+00
R_7351_7352 7351 7352 8.454695e+00
R_7352_7353 7352 7353 6.866299e+00
R_7353_7354 7353 7354 1.982026e+00
R_7354_7355 7354 7355 7.818841e+00
R_7355_7356 7355 7356 8.036567e+00
R_7356_7357 7356 7357 1.642416e+00
R_7357_7358 7357 7358 7.713902e+00
R_7358_7359 7358 7359 9.442086e+00
R_7359_7360 7359 7360 6.954683e+00
R_7360_7361 7360 7361 8.618001e+00
R_7361_7362 7361 7362 7.806943e+00
R_7362_7363 7362 7363 2.073746e-01
R_7363_7364 7363 7364 5.019121e+00
R_7364_7365 7364 7365 4.808101e+00
R_7365_7366 7365 7366 4.415876e+00
R_7366_7367 7366 7367 7.126124e-01
R_7367_7368 7367 7368 8.020114e+00
R_7368_7369 7368 7369 7.945906e+00
R_7369_7370 7369 7370 4.547538e-01
R_7370_7371 7370 7371 6.867917e-01
R_7371_7372 7371 7372 5.685878e+00
R_7372_7373 7372 7373 4.414415e+00
R_7373_7374 7373 7374 3.117078e-01
R_7374_7375 7374 7375 3.630767e+00
R_7375_7376 7375 7376 4.043937e+00
R_7376_7377 7376 7377 6.210683e+00
R_7377_7378 7377 7378 7.216753e+00
R_7378_7379 7378 7379 3.807671e+00
R_7379_7380 7379 7380 8.584671e+00
R_7380_7381 7380 7381 8.246233e-01
R_7381_7382 7381 7382 2.994786e+00
R_7382_7383 7382 7383 7.066247e+00
R_7383_7384 7383 7384 7.210154e+00
R_7384_7385 7384 7385 5.172836e+00
R_7385_7386 7385 7386 5.214943e+00
R_7386_7387 7386 7387 5.347759e+00
R_7387_7388 7387 7388 7.520007e+00
R_7388_7389 7388 7389 3.207235e+00
R_7389_7390 7389 7390 4.079225e-02
R_7390_7391 7390 7391 6.140760e+00
R_7391_7392 7391 7392 2.864389e+00
R_7392_7393 7392 7393 2.644242e+00
R_7393_7394 7393 7394 9.843358e+00
R_7394_7395 7394 7395 8.719940e+00
R_7395_7396 7395 7396 1.609328e+00
R_7396_7397 7396 7397 1.094956e+00
R_7397_7398 7397 7398 7.810489e+00
R_7398_7399 7398 7399 2.438709e+00
R_7399_7400 7399 7400 5.801866e+00
R_7401_7402 7401 7402 9.416381e+00
R_7402_7403 7402 7403 3.711299e+00
R_7403_7404 7403 7404 5.883887e+00
R_7404_7405 7404 7405 3.586684e+00
R_7405_7406 7405 7406 6.648555e+00
R_7406_7407 7406 7407 3.711919e+00
R_7407_7408 7407 7408 7.622614e+00
R_7408_7409 7408 7409 2.739387e+00
R_7409_7410 7409 7410 7.665564e+00
R_7410_7411 7410 7411 1.456157e+00
R_7411_7412 7411 7412 3.852467e+00
R_7412_7413 7412 7413 1.721591e+00
R_7413_7414 7413 7414 5.217145e+00
R_7414_7415 7414 7415 6.202342e+00
R_7415_7416 7415 7416 2.088393e-01
R_7416_7417 7416 7417 7.329752e+00
R_7417_7418 7417 7418 2.994821e+00
R_7418_7419 7418 7419 5.174370e+00
R_7419_7420 7419 7420 1.373306e+00
R_7420_7421 7420 7421 4.655537e+00
R_7421_7422 7421 7422 3.241317e+00
R_7422_7423 7422 7423 6.477463e+00
R_7423_7424 7423 7424 4.033952e+00
R_7424_7425 7424 7425 6.119848e+00
R_7425_7426 7425 7426 8.393234e-01
R_7426_7427 7426 7427 7.219568e+00
R_7427_7428 7427 7428 8.886893e+00
R_7428_7429 7428 7429 3.777249e+00
R_7429_7430 7429 7430 4.063143e+00
R_7430_7431 7430 7431 6.707897e+00
R_7431_7432 7431 7432 6.638174e+00
R_7432_7433 7432 7433 2.783485e-01
R_7433_7434 7433 7434 3.150358e+00
R_7434_7435 7434 7435 3.819860e+00
R_7435_7436 7435 7436 4.594450e+00
R_7436_7437 7436 7437 7.190241e+00
R_7437_7438 7437 7438 9.594509e+00
R_7438_7439 7438 7439 2.500665e+00
R_7439_7440 7439 7440 8.790115e+00
R_7440_7441 7440 7441 2.861722e-02
R_7441_7442 7441 7442 9.747018e+00
R_7442_7443 7442 7443 1.702268e+00
R_7443_7444 7443 7444 4.451929e+00
R_7444_7445 7444 7445 1.963106e+00
R_7445_7446 7445 7446 7.152102e+00
R_7446_7447 7446 7447 2.135130e+00
R_7447_7448 7447 7448 7.581871e+00
R_7448_7449 7448 7449 7.196658e+00
R_7449_7450 7449 7450 5.933822e+00
R_7450_7451 7450 7451 1.070694e+00
R_7451_7452 7451 7452 6.037257e+00
R_7452_7453 7452 7453 4.191783e+00
R_7453_7454 7453 7454 4.503687e-01
R_7454_7455 7454 7455 4.485667e+00
R_7455_7456 7455 7456 7.694817e+00
R_7456_7457 7456 7457 5.248281e+00
R_7457_7458 7457 7458 8.408905e+00
R_7458_7459 7458 7459 6.699049e+00
R_7459_7460 7459 7460 1.678756e+00
R_7460_7461 7460 7461 7.740402e+00
R_7461_7462 7461 7462 1.149444e+00
R_7462_7463 7462 7463 4.905616e+00
R_7463_7464 7463 7464 9.274300e+00
R_7464_7465 7464 7465 1.817828e+00
R_7465_7466 7465 7466 3.138765e+00
R_7466_7467 7466 7467 9.564994e+00
R_7467_7468 7467 7468 1.767594e+00
R_7468_7469 7468 7469 5.166687e+00
R_7469_7470 7469 7470 4.284317e+00
R_7470_7471 7470 7471 5.695141e+00
R_7471_7472 7471 7472 2.545297e+00
R_7472_7473 7472 7473 5.745037e+00
R_7473_7474 7473 7474 6.729123e+00
R_7474_7475 7474 7475 8.872895e+00
R_7475_7476 7475 7476 3.074067e+00
R_7476_7477 7476 7477 7.613831e+00
R_7477_7478 7477 7478 5.377096e+00
R_7478_7479 7478 7479 6.134992e+00
R_7479_7480 7479 7480 4.555916e+00
R_7480_7481 7480 7481 2.808592e+00
R_7481_7482 7481 7482 1.168229e+00
R_7482_7483 7482 7483 9.195235e+00
R_7483_7484 7483 7484 3.203107e+00
R_7484_7485 7484 7485 5.777999e+00
R_7485_7486 7485 7486 8.146579e-01
R_7486_7487 7486 7487 2.077806e+00
R_7487_7488 7487 7488 9.891048e+00
R_7488_7489 7488 7489 9.503858e+00
R_7489_7490 7489 7490 6.745967e+00
R_7490_7491 7490 7491 4.572115e+00
R_7491_7492 7491 7492 1.670543e+00
R_7492_7493 7492 7493 1.854496e+00
R_7493_7494 7493 7494 1.863637e-01
R_7494_7495 7494 7495 8.518756e+00
R_7495_7496 7495 7496 2.111192e+00
R_7496_7497 7496 7497 7.905142e+00
R_7497_7498 7497 7498 6.989094e+00
R_7498_7499 7498 7499 8.739030e-02
R_7499_7500 7499 7500 3.190372e+00
R_7501_7502 7501 7502 2.696284e+00
R_7502_7503 7502 7503 2.761617e+00
R_7503_7504 7503 7504 6.438923e+00
R_7504_7505 7504 7505 6.650437e+00
R_7505_7506 7505 7506 1.052749e+00
R_7506_7507 7506 7507 3.572317e+00
R_7507_7508 7507 7508 6.694572e+00
R_7508_7509 7508 7509 3.110952e+00
R_7509_7510 7509 7510 6.940314e+00
R_7510_7511 7510 7511 9.653479e+00
R_7511_7512 7511 7512 6.121587e-01
R_7512_7513 7512 7513 7.836364e+00
R_7513_7514 7513 7514 7.418897e+00
R_7514_7515 7514 7515 4.291626e+00
R_7515_7516 7515 7516 1.934204e+00
R_7516_7517 7516 7517 1.212367e+00
R_7517_7518 7517 7518 1.536236e+00
R_7518_7519 7518 7519 5.971156e+00
R_7519_7520 7519 7520 2.893315e+00
R_7520_7521 7520 7521 1.326728e+00
R_7521_7522 7521 7522 6.676611e+00
R_7522_7523 7522 7523 4.731278e+00
R_7523_7524 7523 7524 6.189532e+00
R_7524_7525 7524 7525 4.172128e+00
R_7525_7526 7525 7526 8.317428e+00
R_7526_7527 7526 7527 3.444452e-01
R_7527_7528 7527 7528 7.083255e+00
R_7528_7529 7528 7529 6.434669e+00
R_7529_7530 7529 7530 9.289526e+00
R_7530_7531 7530 7531 5.606379e+00
R_7531_7532 7531 7532 7.497076e+00
R_7532_7533 7532 7533 1.989284e+00
R_7533_7534 7533 7534 2.207725e+00
R_7534_7535 7534 7535 4.186635e+00
R_7535_7536 7535 7536 2.625751e+00
R_7536_7537 7536 7537 1.812380e+00
R_7537_7538 7537 7538 5.614674e+00
R_7538_7539 7538 7539 9.746610e+00
R_7539_7540 7539 7540 9.533976e+00
R_7540_7541 7540 7541 2.318202e+00
R_7541_7542 7541 7542 9.100376e+00
R_7542_7543 7542 7543 1.177531e+00
R_7543_7544 7543 7544 6.653820e+00
R_7544_7545 7544 7545 5.782907e-03
R_7545_7546 7545 7546 5.994650e+00
R_7546_7547 7546 7547 3.364512e+00
R_7547_7548 7547 7548 3.293543e+00
R_7548_7549 7548 7549 1.913561e+00
R_7549_7550 7549 7550 1.855298e+00
R_7550_7551 7550 7551 9.938082e+00
R_7551_7552 7551 7552 4.428633e+00
R_7552_7553 7552 7553 5.008752e+00
R_7553_7554 7553 7554 8.830958e+00
R_7554_7555 7554 7555 4.728058e-02
R_7555_7556 7555 7556 3.870779e+00
R_7556_7557 7556 7557 3.364518e+00
R_7557_7558 7557 7558 5.719808e+00
R_7558_7559 7558 7559 5.472122e+00
R_7559_7560 7559 7560 3.130462e+00
R_7560_7561 7560 7561 4.256930e+00
R_7561_7562 7561 7562 2.356680e+00
R_7562_7563 7562 7563 3.916976e+00
R_7563_7564 7563 7564 7.844556e-01
R_7564_7565 7564 7565 6.266777e+00
R_7565_7566 7565 7566 7.332361e+00
R_7566_7567 7566 7567 4.192147e+00
R_7567_7568 7567 7568 7.580655e+00
R_7568_7569 7568 7569 2.155328e+00
R_7569_7570 7569 7570 2.801495e+00
R_7570_7571 7570 7571 9.585946e-01
R_7571_7572 7571 7572 8.097172e-02
R_7572_7573 7572 7573 5.746516e-01
R_7573_7574 7573 7574 9.977274e+00
R_7574_7575 7574 7575 6.958380e+00
R_7575_7576 7575 7576 9.541116e+00
R_7576_7577 7576 7577 5.116646e+00
R_7577_7578 7577 7578 8.430922e+00
R_7578_7579 7578 7579 3.596633e+00
R_7579_7580 7579 7580 6.101048e+00
R_7580_7581 7580 7581 8.377935e+00
R_7581_7582 7581 7582 8.319017e+00
R_7582_7583 7582 7583 9.903394e+00
R_7583_7584 7583 7584 5.661310e+00
R_7584_7585 7584 7585 6.029255e+00
R_7585_7586 7585 7586 4.893820e+00
R_7586_7587 7586 7587 1.997323e+00
R_7587_7588 7587 7588 7.713490e+00
R_7588_7589 7588 7589 4.260492e+00
R_7589_7590 7589 7590 5.574281e+00
R_7590_7591 7590 7591 7.783424e+00
R_7591_7592 7591 7592 9.014016e+00
R_7592_7593 7592 7593 6.653153e+00
R_7593_7594 7593 7594 1.449201e+00
R_7594_7595 7594 7595 5.795480e+00
R_7595_7596 7595 7596 5.502390e+00
R_7596_7597 7596 7597 8.520485e+00
R_7597_7598 7597 7598 7.116670e+00
R_7598_7599 7598 7599 3.401935e+00
R_7599_7600 7599 7600 6.627991e+00
R_7601_7602 7601 7602 7.407411e+00
R_7602_7603 7602 7603 5.247411e+00
R_7603_7604 7603 7604 1.998273e+00
R_7604_7605 7604 7605 6.752863e+00
R_7605_7606 7605 7606 2.461219e+00
R_7606_7607 7606 7607 1.391251e+00
R_7607_7608 7607 7608 5.953565e-01
R_7608_7609 7608 7609 2.029147e-01
R_7609_7610 7609 7610 3.675560e+00
R_7610_7611 7610 7611 3.511406e+00
R_7611_7612 7611 7612 1.182164e+00
R_7612_7613 7612 7613 8.199479e+00
R_7613_7614 7613 7614 7.010908e+00
R_7614_7615 7614 7615 1.915389e+00
R_7615_7616 7615 7616 3.218099e+00
R_7616_7617 7616 7617 6.065809e+00
R_7617_7618 7617 7618 1.942943e+00
R_7618_7619 7618 7619 9.086548e-01
R_7619_7620 7619 7620 3.696640e+00
R_7620_7621 7620 7621 8.258276e+00
R_7621_7622 7621 7622 2.075785e-01
R_7622_7623 7622 7623 4.052841e+00
R_7623_7624 7623 7624 4.978714e+00
R_7624_7625 7624 7625 7.369420e-01
R_7625_7626 7625 7626 3.288132e+00
R_7626_7627 7626 7627 2.844451e+00
R_7627_7628 7627 7628 9.691233e+00
R_7628_7629 7628 7629 7.492563e+00
R_7629_7630 7629 7630 3.538007e-01
R_7630_7631 7630 7631 8.761967e+00
R_7631_7632 7631 7632 1.018579e+00
R_7632_7633 7632 7633 5.679161e+00
R_7633_7634 7633 7634 1.256255e+00
R_7634_7635 7634 7635 3.358321e-01
R_7635_7636 7635 7636 2.685351e+00
R_7636_7637 7636 7637 7.853084e+00
R_7637_7638 7637 7638 3.753457e-01
R_7638_7639 7638 7639 1.130524e+00
R_7639_7640 7639 7640 6.986770e+00
R_7640_7641 7640 7641 2.824287e+00
R_7641_7642 7641 7642 9.132787e+00
R_7642_7643 7642 7643 7.663199e+00
R_7643_7644 7643 7644 6.843185e+00
R_7644_7645 7644 7645 4.761502e+00
R_7645_7646 7645 7646 6.466486e+00
R_7646_7647 7646 7647 4.194279e+00
R_7647_7648 7647 7648 4.801341e+00
R_7648_7649 7648 7649 8.032544e+00
R_7649_7650 7649 7650 5.646573e+00
R_7650_7651 7650 7651 8.770356e+00
R_7651_7652 7651 7652 7.156761e+00
R_7652_7653 7652 7653 4.400919e-01
R_7653_7654 7653 7654 2.443910e+00
R_7654_7655 7654 7655 6.558566e+00
R_7655_7656 7655 7656 4.415127e+00
R_7656_7657 7656 7657 1.122340e+00
R_7657_7658 7657 7658 4.808540e+00
R_7658_7659 7658 7659 7.497012e+00
R_7659_7660 7659 7660 7.292921e+00
R_7660_7661 7660 7661 8.472217e+00
R_7661_7662 7661 7662 7.778250e+00
R_7662_7663 7662 7663 5.849129e+00
R_7663_7664 7663 7664 6.014944e-02
R_7664_7665 7664 7665 9.175957e+00
R_7665_7666 7665 7666 3.783548e+00
R_7666_7667 7666 7667 2.628471e+00
R_7667_7668 7667 7668 6.570976e+00
R_7668_7669 7668 7669 3.698680e+00
R_7669_7670 7669 7670 5.490622e+00
R_7670_7671 7670 7671 2.692104e+00
R_7671_7672 7671 7672 8.409726e+00
R_7672_7673 7672 7673 8.283059e+00
R_7673_7674 7673 7674 1.674885e+00
R_7674_7675 7674 7675 2.803363e+00
R_7675_7676 7675 7676 5.334900e+00
R_7676_7677 7676 7677 9.963139e+00
R_7677_7678 7677 7678 1.787031e+00
R_7678_7679 7678 7679 2.151980e+00
R_7679_7680 7679 7680 4.407681e+00
R_7680_7681 7680 7681 6.375651e+00
R_7681_7682 7681 7682 2.359432e+00
R_7682_7683 7682 7683 1.702739e+00
R_7683_7684 7683 7684 1.829491e+00
R_7684_7685 7684 7685 7.566285e+00
R_7685_7686 7685 7686 7.658795e+00
R_7686_7687 7686 7687 8.641709e-01
R_7687_7688 7687 7688 6.384946e+00
R_7688_7689 7688 7689 8.697865e+00
R_7689_7690 7689 7690 5.494323e+00
R_7690_7691 7690 7691 4.263806e+00
R_7691_7692 7691 7692 9.697283e+00
R_7692_7693 7692 7693 4.046273e+00
R_7693_7694 7693 7694 6.216155e+00
R_7694_7695 7694 7695 4.524076e+00
R_7695_7696 7695 7696 4.143598e+00
R_7696_7697 7696 7697 2.155761e+00
R_7697_7698 7697 7698 1.695990e+00
R_7698_7699 7698 7699 7.844813e+00
R_7699_7700 7699 7700 5.275861e+00
R_7701_7702 7701 7702 7.973174e+00
R_7702_7703 7702 7703 3.170416e+00
R_7703_7704 7703 7704 6.520818e+00
R_7704_7705 7704 7705 8.153271e+00
R_7705_7706 7705 7706 6.152134e+00
R_7706_7707 7706 7707 6.067442e+00
R_7707_7708 7707 7708 9.166204e+00
R_7708_7709 7708 7709 8.110136e+00
R_7709_7710 7709 7710 2.430522e+00
R_7710_7711 7710 7711 3.059912e-01
R_7711_7712 7711 7712 2.055906e+00
R_7712_7713 7712 7713 1.784724e+00
R_7713_7714 7713 7714 7.454909e+00
R_7714_7715 7714 7715 7.736668e+00
R_7715_7716 7715 7716 4.375437e+00
R_7716_7717 7716 7717 4.163251e+00
R_7717_7718 7717 7718 2.851544e+00
R_7718_7719 7718 7719 9.258964e+00
R_7719_7720 7719 7720 6.643698e+00
R_7720_7721 7720 7721 5.538054e+00
R_7721_7722 7721 7722 5.496194e+00
R_7722_7723 7722 7723 8.652674e+00
R_7723_7724 7723 7724 3.805581e+00
R_7724_7725 7724 7725 7.472431e-01
R_7725_7726 7725 7726 5.176043e+00
R_7726_7727 7726 7727 5.923922e+00
R_7727_7728 7727 7728 4.741678e+00
R_7728_7729 7728 7729 6.835026e+00
R_7729_7730 7729 7730 3.968613e+00
R_7730_7731 7730 7731 6.090802e+00
R_7731_7732 7731 7732 5.059349e+00
R_7732_7733 7732 7733 4.133286e+00
R_7733_7734 7733 7734 2.251783e+00
R_7734_7735 7734 7735 3.668191e+00
R_7735_7736 7735 7736 4.346030e+00
R_7736_7737 7736 7737 7.164300e+00
R_7737_7738 7737 7738 1.750141e+00
R_7738_7739 7738 7739 1.022405e+00
R_7739_7740 7739 7740 2.345234e+00
R_7740_7741 7740 7741 5.974185e+00
R_7741_7742 7741 7742 2.493323e+00
R_7742_7743 7742 7743 9.105854e+00
R_7743_7744 7743 7744 3.197384e+00
R_7744_7745 7744 7745 6.740038e+00
R_7745_7746 7745 7746 3.755389e+00
R_7746_7747 7746 7747 5.261005e+00
R_7747_7748 7747 7748 5.797481e-01
R_7748_7749 7748 7749 9.111157e+00
R_7749_7750 7749 7750 6.421273e+00
R_7750_7751 7750 7751 5.571708e+00
R_7751_7752 7751 7752 5.496368e+00
R_7752_7753 7752 7753 2.746256e+00
R_7753_7754 7753 7754 8.112826e+00
R_7754_7755 7754 7755 4.119098e+00
R_7755_7756 7755 7756 4.147017e+00
R_7756_7757 7756 7757 4.278909e+00
R_7757_7758 7757 7758 9.134312e+00
R_7758_7759 7758 7759 7.839024e+00
R_7759_7760 7759 7760 6.033422e+00
R_7760_7761 7760 7761 8.148888e+00
R_7761_7762 7761 7762 1.283267e+00
R_7762_7763 7762 7763 4.030720e+00
R_7763_7764 7763 7764 2.795298e+00
R_7764_7765 7764 7765 7.975926e+00
R_7765_7766 7765 7766 7.644774e+00
R_7766_7767 7766 7767 6.195156e+00
R_7767_7768 7767 7768 9.587050e+00
R_7768_7769 7768 7769 9.035236e+00
R_7769_7770 7769 7770 8.056615e+00
R_7770_7771 7770 7771 2.393826e+00
R_7771_7772 7771 7772 2.430360e+00
R_7772_7773 7772 7773 7.720958e+00
R_7773_7774 7773 7774 7.184702e+00
R_7774_7775 7774 7775 6.180747e+00
R_7775_7776 7775 7776 1.564544e+00
R_7776_7777 7776 7777 2.622826e-01
R_7777_7778 7777 7778 3.832857e+00
R_7778_7779 7778 7779 2.769053e+00
R_7779_7780 7779 7780 2.103803e+00
R_7780_7781 7780 7781 4.587201e+00
R_7781_7782 7781 7782 2.433518e+00
R_7782_7783 7782 7783 8.824054e-02
R_7783_7784 7783 7784 4.424786e+00
R_7784_7785 7784 7785 9.070434e+00
R_7785_7786 7785 7786 2.080500e+00
R_7786_7787 7786 7787 5.127172e-01
R_7787_7788 7787 7788 6.435835e+00
R_7788_7789 7788 7789 5.994629e+00
R_7789_7790 7789 7790 5.210331e+00
R_7790_7791 7790 7791 6.499485e+00
R_7791_7792 7791 7792 3.461960e+00
R_7792_7793 7792 7793 5.526663e+00
R_7793_7794 7793 7794 4.147581e+00
R_7794_7795 7794 7795 6.972352e+00
R_7795_7796 7795 7796 6.859775e+00
R_7796_7797 7796 7797 3.697371e+00
R_7797_7798 7797 7798 6.046709e+00
R_7798_7799 7798 7799 5.493024e+00
R_7799_7800 7799 7800 1.530834e+00
R_7801_7802 7801 7802 1.901041e+00
R_7802_7803 7802 7803 2.183853e+00
R_7803_7804 7803 7804 6.721697e+00
R_7804_7805 7804 7805 7.767203e+00
R_7805_7806 7805 7806 4.671634e+00
R_7806_7807 7806 7807 1.121939e+00
R_7807_7808 7807 7808 4.214031e+00
R_7808_7809 7808 7809 6.976894e+00
R_7809_7810 7809 7810 5.761195e+00
R_7810_7811 7810 7811 8.320873e+00
R_7811_7812 7811 7812 4.033159e+00
R_7812_7813 7812 7813 4.026607e-01
R_7813_7814 7813 7814 9.032961e+00
R_7814_7815 7814 7815 1.613460e+00
R_7815_7816 7815 7816 5.066131e+00
R_7816_7817 7816 7817 4.440634e+00
R_7817_7818 7817 7818 8.655746e+00
R_7818_7819 7818 7819 2.364616e+00
R_7819_7820 7819 7820 8.722880e+00
R_7820_7821 7820 7821 4.425433e+00
R_7821_7822 7821 7822 6.883727e-01
R_7822_7823 7822 7823 2.863440e+00
R_7823_7824 7823 7824 7.349817e+00
R_7824_7825 7824 7825 4.379573e+00
R_7825_7826 7825 7826 1.003122e+00
R_7826_7827 7826 7827 4.987203e+00
R_7827_7828 7827 7828 9.007307e+00
R_7828_7829 7828 7829 4.286913e+00
R_7829_7830 7829 7830 4.125424e+00
R_7830_7831 7830 7831 6.962591e+00
R_7831_7832 7831 7832 2.347433e+00
R_7832_7833 7832 7833 3.246718e+00
R_7833_7834 7833 7834 3.602791e+00
R_7834_7835 7834 7835 6.260510e+00
R_7835_7836 7835 7836 6.169584e+00
R_7836_7837 7836 7837 1.777182e+00
R_7837_7838 7837 7838 6.599423e+00
R_7838_7839 7838 7839 8.706382e+00
R_7839_7840 7839 7840 9.953292e+00
R_7840_7841 7840 7841 3.772842e-01
R_7841_7842 7841 7842 5.591624e+00
R_7842_7843 7842 7843 2.977053e+00
R_7843_7844 7843 7844 4.792099e+00
R_7844_7845 7844 7845 9.045872e+00
R_7845_7846 7845 7846 5.689778e+00
R_7846_7847 7846 7847 1.046636e+00
R_7847_7848 7847 7848 2.529115e+00
R_7848_7849 7848 7849 8.914821e+00
R_7849_7850 7849 7850 3.879672e+00
R_7850_7851 7850 7851 8.875099e+00
R_7851_7852 7851 7852 2.485132e+00
R_7852_7853 7852 7853 9.347355e+00
R_7853_7854 7853 7854 4.722575e+00
R_7854_7855 7854 7855 5.219447e+00
R_7855_7856 7855 7856 5.071781e+00
R_7856_7857 7856 7857 4.891763e+00
R_7857_7858 7857 7858 3.712224e+00
R_7858_7859 7858 7859 9.768316e+00
R_7859_7860 7859 7860 7.583084e+00
R_7860_7861 7860 7861 6.190020e+00
R_7861_7862 7861 7862 8.263685e+00
R_7862_7863 7862 7863 6.046873e+00
R_7863_7864 7863 7864 3.903385e+00
R_7864_7865 7864 7865 2.619760e+00
R_7865_7866 7865 7866 1.431810e+00
R_7866_7867 7866 7867 7.850913e+00
R_7867_7868 7867 7868 4.838214e-01
R_7868_7869 7868 7869 7.682556e+00
R_7869_7870 7869 7870 5.046748e+00
R_7870_7871 7870 7871 9.820975e+00
R_7871_7872 7871 7872 4.189770e+00
R_7872_7873 7872 7873 1.544643e+00
R_7873_7874 7873 7874 9.861482e+00
R_7874_7875 7874 7875 7.643781e+00
R_7875_7876 7875 7876 9.687980e+00
R_7876_7877 7876 7877 1.400568e+00
R_7877_7878 7877 7878 2.216571e+00
R_7878_7879 7878 7879 6.820587e+00
R_7879_7880 7879 7880 5.913729e+00
R_7880_7881 7880 7881 5.955372e+00
R_7881_7882 7881 7882 8.484269e+00
R_7882_7883 7882 7883 8.678831e-01
R_7883_7884 7883 7884 9.065548e+00
R_7884_7885 7884 7885 1.204634e+00
R_7885_7886 7885 7886 9.892986e+00
R_7886_7887 7886 7887 3.995576e+00
R_7887_7888 7887 7888 2.336471e+00
R_7888_7889 7888 7889 7.187239e+00
R_7889_7890 7889 7890 9.841499e+00
R_7890_7891 7890 7891 2.159892e+00
R_7891_7892 7891 7892 3.169561e+00
R_7892_7893 7892 7893 1.434163e+00
R_7893_7894 7893 7894 7.934112e+00
R_7894_7895 7894 7895 8.257218e-01
R_7895_7896 7895 7896 2.366336e+00
R_7896_7897 7896 7897 3.422611e+00
R_7897_7898 7897 7898 9.147402e+00
R_7898_7899 7898 7899 7.276947e+00
R_7899_7900 7899 7900 8.422711e+00
R_7901_7902 7901 7902 9.386815e+00
R_7902_7903 7902 7903 7.534612e+00
R_7903_7904 7903 7904 5.578383e+00
R_7904_7905 7904 7905 6.970614e+00
R_7905_7906 7905 7906 2.625252e+00
R_7906_7907 7906 7907 1.105450e+00
R_7907_7908 7907 7908 3.383804e+00
R_7908_7909 7908 7909 2.436798e+00
R_7909_7910 7909 7910 1.529824e+00
R_7910_7911 7910 7911 4.933178e+00
R_7911_7912 7911 7912 8.733429e+00
R_7912_7913 7912 7913 5.000385e+00
R_7913_7914 7913 7914 5.308440e+00
R_7914_7915 7914 7915 1.433830e+00
R_7915_7916 7915 7916 3.402843e+00
R_7916_7917 7916 7917 9.088316e+00
R_7917_7918 7917 7918 7.518355e+00
R_7918_7919 7918 7919 9.832823e+00
R_7919_7920 7919 7920 7.691425e+00
R_7920_7921 7920 7921 1.107869e+00
R_7921_7922 7921 7922 9.001000e+00
R_7922_7923 7922 7923 5.202973e-01
R_7923_7924 7923 7924 8.900173e+00
R_7924_7925 7924 7925 4.997538e+00
R_7925_7926 7925 7926 9.454124e+00
R_7926_7927 7926 7927 5.955145e-01
R_7927_7928 7927 7928 6.926126e+00
R_7928_7929 7928 7929 1.808907e+00
R_7929_7930 7929 7930 6.733078e+00
R_7930_7931 7930 7931 4.329381e+00
R_7931_7932 7931 7932 8.743287e+00
R_7932_7933 7932 7933 1.112166e+00
R_7933_7934 7933 7934 6.223191e+00
R_7934_7935 7934 7935 2.177720e+00
R_7935_7936 7935 7936 1.323641e+00
R_7936_7937 7936 7937 3.866554e-01
R_7937_7938 7937 7938 7.154519e+00
R_7938_7939 7938 7939 5.895248e-01
R_7939_7940 7939 7940 3.177814e+00
R_7940_7941 7940 7941 1.157048e+00
R_7941_7942 7941 7942 5.144349e-01
R_7942_7943 7942 7943 5.630535e+00
R_7943_7944 7943 7944 3.496823e+00
R_7944_7945 7944 7945 3.578486e+00
R_7945_7946 7945 7946 8.341852e+00
R_7946_7947 7946 7947 8.253483e+00
R_7947_7948 7947 7948 4.547305e+00
R_7948_7949 7948 7949 6.729422e+00
R_7949_7950 7949 7950 9.386090e+00
R_7950_7951 7950 7951 4.704428e+00
R_7951_7952 7951 7952 4.693345e+00
R_7952_7953 7952 7953 5.425840e+00
R_7953_7954 7953 7954 5.843178e+00
R_7954_7955 7954 7955 9.771660e+00
R_7955_7956 7955 7956 1.710185e+00
R_7956_7957 7956 7957 4.005396e+00
R_7957_7958 7957 7958 8.078184e+00
R_7958_7959 7958 7959 6.007298e+00
R_7959_7960 7959 7960 5.791075e+00
R_7960_7961 7960 7961 1.662965e+00
R_7961_7962 7961 7962 5.566376e+00
R_7962_7963 7962 7963 9.835009e+00
R_7963_7964 7963 7964 6.055083e+00
R_7964_7965 7964 7965 9.458562e+00
R_7965_7966 7965 7966 1.421658e+00
R_7966_7967 7966 7967 8.815419e+00
R_7967_7968 7967 7968 9.982186e+00
R_7968_7969 7968 7969 9.503300e+00
R_7969_7970 7969 7970 1.446515e+00
R_7970_7971 7970 7971 6.759554e+00
R_7971_7972 7971 7972 7.095459e-01
R_7972_7973 7972 7973 3.816512e-01
R_7973_7974 7973 7974 1.667802e+00
R_7974_7975 7974 7975 5.953990e+00
R_7975_7976 7975 7976 8.553325e+00
R_7976_7977 7976 7977 8.909406e+00
R_7977_7978 7977 7978 3.768906e+00
R_7978_7979 7978 7979 9.498495e+00
R_7979_7980 7979 7980 9.838842e+00
R_7980_7981 7980 7981 1.290883e+00
R_7981_7982 7981 7982 3.157720e+00
R_7982_7983 7982 7983 3.953906e+00
R_7983_7984 7983 7984 9.311471e+00
R_7984_7985 7984 7985 2.392953e+00
R_7985_7986 7985 7986 6.800249e+00
R_7986_7987 7986 7987 8.352196e-01
R_7987_7988 7987 7988 7.057175e+00
R_7988_7989 7988 7989 6.976504e+00
R_7989_7990 7989 7990 7.181234e+00
R_7990_7991 7990 7991 2.878072e+00
R_7991_7992 7991 7992 9.053658e-01
R_7992_7993 7992 7993 4.977467e-01
R_7993_7994 7993 7994 5.060810e+00
R_7994_7995 7994 7995 9.221602e+00
R_7995_7996 7995 7996 8.776517e+00
R_7996_7997 7996 7997 9.940313e+00
R_7997_7998 7997 7998 2.859100e+00
R_7998_7999 7998 7999 4.440375e+00
R_7999_8000 7999 8000 9.423170e+00
R_8001_8002 8001 8002 1.505614e+00
R_8002_8003 8002 8003 9.962940e+00
R_8003_8004 8003 8004 9.497431e+00
R_8004_8005 8004 8005 5.619431e+00
R_8005_8006 8005 8006 4.720543e-01
R_8006_8007 8006 8007 7.640162e+00
R_8007_8008 8007 8008 3.694831e+00
R_8008_8009 8008 8009 7.773177e+00
R_8009_8010 8009 8010 5.800634e+00
R_8010_8011 8010 8011 6.122442e+00
R_8011_8012 8011 8012 9.584400e+00
R_8012_8013 8012 8013 8.959920e+00
R_8013_8014 8013 8014 1.546864e-01
R_8014_8015 8014 8015 4.605635e+00
R_8015_8016 8015 8016 2.026967e+00
R_8016_8017 8016 8017 9.540649e+00
R_8017_8018 8017 8018 4.929003e-01
R_8018_8019 8018 8019 5.241511e+00
R_8019_8020 8019 8020 8.796154e+00
R_8020_8021 8020 8021 4.881503e+00
R_8021_8022 8021 8022 4.431626e+00
R_8022_8023 8022 8023 7.410931e+00
R_8023_8024 8023 8024 3.742760e+00
R_8024_8025 8024 8025 8.871215e+00
R_8025_8026 8025 8026 4.042387e+00
R_8026_8027 8026 8027 3.142123e-01
R_8027_8028 8027 8028 9.273235e+00
R_8028_8029 8028 8029 1.001571e-01
R_8029_8030 8029 8030 4.766918e+00
R_8030_8031 8030 8031 3.846652e+00
R_8031_8032 8031 8032 3.635456e+00
R_8032_8033 8032 8033 8.680862e+00
R_8033_8034 8033 8034 8.716021e+00
R_8034_8035 8034 8035 5.649838e-01
R_8035_8036 8035 8036 3.660569e+00
R_8036_8037 8036 8037 8.407948e+00
R_8037_8038 8037 8038 4.243782e+00
R_8038_8039 8038 8039 5.307477e+00
R_8039_8040 8039 8040 1.574377e+00
R_8040_8041 8040 8041 2.535288e+00
R_8041_8042 8041 8042 7.200646e+00
R_8042_8043 8042 8043 7.975078e+00
R_8043_8044 8043 8044 7.128446e+00
R_8044_8045 8044 8045 4.446701e+00
R_8045_8046 8045 8046 5.631237e-01
R_8046_8047 8046 8047 9.464823e-01
R_8047_8048 8047 8048 6.498129e+00
R_8048_8049 8048 8049 1.499900e+00
R_8049_8050 8049 8050 8.575635e-01
R_8050_8051 8050 8051 4.583785e+00
R_8051_8052 8051 8052 1.482346e-01
R_8052_8053 8052 8053 5.679009e+00
R_8053_8054 8053 8054 8.357824e+00
R_8054_8055 8054 8055 8.787818e+00
R_8055_8056 8055 8056 8.755160e+00
R_8056_8057 8056 8057 6.858958e+00
R_8057_8058 8057 8058 3.767181e+00
R_8058_8059 8058 8059 2.358613e+00
R_8059_8060 8059 8060 2.657640e+00
R_8060_8061 8060 8061 2.146659e-01
R_8061_8062 8061 8062 6.325728e+00
R_8062_8063 8062 8063 7.627292e+00
R_8063_8064 8063 8064 7.330668e+00
R_8064_8065 8064 8065 7.256006e+00
R_8065_8066 8065 8066 9.103612e+00
R_8066_8067 8066 8067 9.465945e+00
R_8067_8068 8067 8068 6.320915e+00
R_8068_8069 8068 8069 9.950492e+00
R_8069_8070 8069 8070 2.867536e+00
R_8070_8071 8070 8071 7.145620e+00
R_8071_8072 8071 8072 7.108488e+00
R_8072_8073 8072 8073 4.591568e+00
R_8073_8074 8073 8074 4.983898e+00
R_8074_8075 8074 8075 2.276869e+00
R_8075_8076 8075 8076 4.242302e+00
R_8076_8077 8076 8077 6.019886e-01
R_8077_8078 8077 8078 1.830597e+00
R_8078_8079 8078 8079 3.449398e+00
R_8079_8080 8079 8080 5.648406e+00
R_8080_8081 8080 8081 5.202575e+00
R_8081_8082 8081 8082 6.329819e+00
R_8082_8083 8082 8083 7.606016e+00
R_8083_8084 8083 8084 2.118358e-01
R_8084_8085 8084 8085 4.337870e+00
R_8085_8086 8085 8086 4.360156e+00
R_8086_8087 8086 8087 2.204214e+00
R_8087_8088 8087 8088 5.041581e+00
R_8088_8089 8088 8089 1.040523e+00
R_8089_8090 8089 8090 5.413283e+00
R_8090_8091 8090 8091 9.267164e+00
R_8091_8092 8091 8092 3.155353e+00
R_8092_8093 8092 8093 6.207317e+00
R_8093_8094 8093 8094 7.854720e+00
R_8094_8095 8094 8095 8.125021e+00
R_8095_8096 8095 8096 9.499578e+00
R_8096_8097 8096 8097 7.033444e+00
R_8097_8098 8097 8098 6.063951e+00
R_8098_8099 8098 8099 2.831241e+00
R_8099_8100 8099 8100 8.605638e-02
R_8101_8102 8101 8102 9.121215e+00
R_8102_8103 8102 8103 7.898245e+00
R_8103_8104 8103 8104 3.891587e+00
R_8104_8105 8104 8105 7.214256e+00
R_8105_8106 8105 8106 1.221619e+00
R_8106_8107 8106 8107 8.600563e+00
R_8107_8108 8107 8108 1.900567e+00
R_8108_8109 8108 8109 7.793147e+00
R_8109_8110 8109 8110 8.107694e+00
R_8110_8111 8110 8111 8.317673e+00
R_8111_8112 8111 8112 5.428283e+00
R_8112_8113 8112 8113 4.048103e+00
R_8113_8114 8113 8114 1.959558e+00
R_8114_8115 8114 8115 4.024167e+00
R_8115_8116 8115 8116 5.901842e+00
R_8116_8117 8116 8117 1.216684e+00
R_8117_8118 8117 8118 2.383221e+00
R_8118_8119 8118 8119 8.985456e+00
R_8119_8120 8119 8120 3.623599e+00
R_8120_8121 8120 8121 9.297804e+00
R_8121_8122 8121 8122 9.582702e+00
R_8122_8123 8122 8123 4.867763e+00
R_8123_8124 8123 8124 5.298762e+00
R_8124_8125 8124 8125 7.933295e+00
R_8125_8126 8125 8126 4.667394e+00
R_8126_8127 8126 8127 5.207719e+00
R_8127_8128 8127 8128 6.147365e+00
R_8128_8129 8128 8129 7.127925e+00
R_8129_8130 8129 8130 4.002417e+00
R_8130_8131 8130 8131 7.484281e+00
R_8131_8132 8131 8132 4.287047e+00
R_8132_8133 8132 8133 4.267521e+00
R_8133_8134 8133 8134 9.340495e+00
R_8134_8135 8134 8135 5.267521e+00
R_8135_8136 8135 8136 1.941492e+00
R_8136_8137 8136 8137 6.685539e+00
R_8137_8138 8137 8138 3.382851e-01
R_8138_8139 8138 8139 6.877590e+00
R_8139_8140 8139 8140 2.515773e+00
R_8140_8141 8140 8141 6.543938e+00
R_8141_8142 8141 8142 7.677399e+00
R_8142_8143 8142 8143 6.060162e+00
R_8143_8144 8143 8144 9.178387e+00
R_8144_8145 8144 8145 4.274801e-01
R_8145_8146 8145 8146 3.265352e+00
R_8146_8147 8146 8147 5.580745e+00
R_8147_8148 8147 8148 7.072535e+00
R_8148_8149 8148 8149 1.809405e+00
R_8149_8150 8149 8150 8.979266e+00
R_8150_8151 8150 8151 6.870280e+00
R_8151_8152 8151 8152 2.749016e+00
R_8152_8153 8152 8153 1.211955e+00
R_8153_8154 8153 8154 6.057999e+00
R_8154_8155 8154 8155 7.092189e+00
R_8155_8156 8155 8156 2.942789e-01
R_8156_8157 8156 8157 6.826929e+00
R_8157_8158 8157 8158 1.940170e+00
R_8158_8159 8158 8159 4.525209e+00
R_8159_8160 8159 8160 1.150617e+00
R_8160_8161 8160 8161 8.281166e+00
R_8161_8162 8161 8162 9.902872e+00
R_8162_8163 8162 8163 3.818199e-01
R_8163_8164 8163 8164 6.058031e+00
R_8164_8165 8164 8165 8.785244e+00
R_8165_8166 8165 8166 7.692169e+00
R_8166_8167 8166 8167 3.853823e+00
R_8167_8168 8167 8168 2.261635e+00
R_8168_8169 8168 8169 1.184109e+00
R_8169_8170 8169 8170 9.199336e+00
R_8170_8171 8170 8171 4.605251e+00
R_8171_8172 8171 8172 1.105327e-02
R_8172_8173 8172 8173 6.359704e+00
R_8173_8174 8173 8174 4.299561e+00
R_8174_8175 8174 8175 9.900518e+00
R_8175_8176 8175 8176 7.593148e+00
R_8176_8177 8176 8177 5.913758e+00
R_8177_8178 8177 8178 9.364975e+00
R_8178_8179 8178 8179 3.071048e-01
R_8179_8180 8179 8180 4.973557e+00
R_8180_8181 8180 8181 7.184815e+00
R_8181_8182 8181 8182 3.531561e+00
R_8182_8183 8182 8183 1.328854e+00
R_8183_8184 8183 8184 6.660292e+00
R_8184_8185 8184 8185 6.112106e+00
R_8185_8186 8185 8186 5.598302e+00
R_8186_8187 8186 8187 8.019215e+00
R_8187_8188 8187 8188 4.164183e-01
R_8188_8189 8188 8189 8.185557e+00
R_8189_8190 8189 8190 5.134049e-01
R_8190_8191 8190 8191 2.487963e-01
R_8191_8192 8191 8192 5.322062e+00
R_8192_8193 8192 8193 7.979624e+00
R_8193_8194 8193 8194 9.062977e+00
R_8194_8195 8194 8195 6.171892e+00
R_8195_8196 8195 8196 7.175424e-01
R_8196_8197 8196 8197 5.158871e+00
R_8197_8198 8197 8198 9.084330e+00
R_8198_8199 8198 8199 4.979182e+00
R_8199_8200 8199 8200 1.743748e+00
R_8201_8202 8201 8202 9.658514e+00
R_8202_8203 8202 8203 4.333038e+00
R_8203_8204 8203 8204 8.638140e-01
R_8204_8205 8204 8205 9.885371e+00
R_8205_8206 8205 8206 2.098580e+00
R_8206_8207 8206 8207 6.622795e+00
R_8207_8208 8207 8208 7.437935e+00
R_8208_8209 8208 8209 9.000238e+00
R_8209_8210 8209 8210 8.970975e+00
R_8210_8211 8210 8211 6.936313e-01
R_8211_8212 8211 8212 1.206219e+00
R_8212_8213 8212 8213 4.158958e+00
R_8213_8214 8213 8214 6.269412e-01
R_8214_8215 8214 8215 3.053762e+00
R_8215_8216 8215 8216 3.803630e+00
R_8216_8217 8216 8217 9.186927e+00
R_8217_8218 8217 8218 1.457412e+00
R_8218_8219 8218 8219 9.729971e+00
R_8219_8220 8219 8220 5.676426e+00
R_8220_8221 8220 8221 4.258610e+00
R_8221_8222 8221 8222 4.319983e-01
R_8222_8223 8222 8223 1.278275e+00
R_8223_8224 8223 8224 3.178273e+00
R_8224_8225 8224 8225 7.047715e+00
R_8225_8226 8225 8226 2.948375e-01
R_8226_8227 8226 8227 8.399749e-01
R_8227_8228 8227 8228 8.793858e+00
R_8228_8229 8228 8229 6.442212e+00
R_8229_8230 8229 8230 8.676014e+00
R_8230_8231 8230 8231 5.367029e+00
R_8231_8232 8231 8232 1.521177e+00
R_8232_8233 8232 8233 9.131306e+00
R_8233_8234 8233 8234 7.169443e-01
R_8234_8235 8234 8235 4.696078e-01
R_8235_8236 8235 8236 4.207078e+00
R_8236_8237 8236 8237 7.869675e+00
R_8237_8238 8237 8238 3.526168e+00
R_8238_8239 8238 8239 8.305030e+00
R_8239_8240 8239 8240 1.576215e+00
R_8240_8241 8240 8241 6.546879e+00
R_8241_8242 8241 8242 5.765286e+00
R_8242_8243 8242 8243 9.882104e+00
R_8243_8244 8243 8244 6.503778e+00
R_8244_8245 8244 8245 9.232331e+00
R_8245_8246 8245 8246 2.083754e+00
R_8246_8247 8246 8247 6.302783e+00
R_8247_8248 8247 8248 8.781156e+00
R_8248_8249 8248 8249 5.044347e+00
R_8249_8250 8249 8250 8.796276e+00
R_8250_8251 8250 8251 3.881152e+00
R_8251_8252 8251 8252 3.521628e+00
R_8252_8253 8252 8253 2.253114e+00
R_8253_8254 8253 8254 2.187986e+00
R_8254_8255 8254 8255 5.617573e+00
R_8255_8256 8255 8256 1.887771e+00
R_8256_8257 8256 8257 2.535315e+00
R_8257_8258 8257 8258 9.380588e+00
R_8258_8259 8258 8259 4.688498e+00
R_8259_8260 8259 8260 9.390044e+00
R_8260_8261 8260 8261 5.860234e+00
R_8261_8262 8261 8262 9.468767e+00
R_8262_8263 8262 8263 3.769620e+00
R_8263_8264 8263 8264 1.081592e-01
R_8264_8265 8264 8265 5.654436e+00
R_8265_8266 8265 8266 2.606513e+00
R_8266_8267 8266 8267 8.333487e+00
R_8267_8268 8267 8268 7.895932e+00
R_8268_8269 8268 8269 4.280224e+00
R_8269_8270 8269 8270 9.034192e+00
R_8270_8271 8270 8271 4.987056e+00
R_8271_8272 8271 8272 1.191552e+00
R_8272_8273 8272 8273 8.131205e+00
R_8273_8274 8273 8274 5.383751e+00
R_8274_8275 8274 8275 6.147074e+00
R_8275_8276 8275 8276 7.496079e+00
R_8276_8277 8276 8277 6.299816e+00
R_8277_8278 8277 8278 4.570919e+00
R_8278_8279 8278 8279 3.996693e+00
R_8279_8280 8279 8280 3.247214e-01
R_8280_8281 8280 8281 9.651586e+00
R_8281_8282 8281 8282 1.698347e+00
R_8282_8283 8282 8283 4.476059e-01
R_8283_8284 8283 8284 6.140686e+00
R_8284_8285 8284 8285 3.782283e+00
R_8285_8286 8285 8286 2.101995e+00
R_8286_8287 8286 8287 7.173798e+00
R_8287_8288 8287 8288 6.441999e+00
R_8288_8289 8288 8289 5.075777e+00
R_8289_8290 8289 8290 8.381922e-03
R_8290_8291 8290 8291 9.830505e+00
R_8291_8292 8291 8292 3.039817e+00
R_8292_8293 8292 8293 5.833675e+00
R_8293_8294 8293 8294 7.414865e+00
R_8294_8295 8294 8295 6.238115e+00
R_8295_8296 8295 8296 4.111532e+00
R_8296_8297 8296 8297 4.319102e+00
R_8297_8298 8297 8298 3.412788e-01
R_8298_8299 8298 8299 6.782320e+00
R_8299_8300 8299 8300 8.039609e+00
R_8301_8302 8301 8302 9.907882e+00
R_8302_8303 8302 8303 4.134361e+00
R_8303_8304 8303 8304 9.884207e+00
R_8304_8305 8304 8305 9.341525e+00
R_8305_8306 8305 8306 4.684364e+00
R_8306_8307 8306 8307 9.153337e+00
R_8307_8308 8307 8308 1.661076e+00
R_8308_8309 8308 8309 4.790025e+00
R_8309_8310 8309 8310 6.837270e-01
R_8310_8311 8310 8311 2.704913e+00
R_8311_8312 8311 8312 7.097239e+00
R_8312_8313 8312 8313 4.226218e+00
R_8313_8314 8313 8314 3.052791e-01
R_8314_8315 8314 8315 7.114185e+00
R_8315_8316 8315 8316 7.739591e+00
R_8316_8317 8316 8317 1.546219e+00
R_8317_8318 8317 8318 6.884924e+00
R_8318_8319 8318 8319 8.712396e+00
R_8319_8320 8319 8320 6.529206e+00
R_8320_8321 8320 8321 1.720807e+00
R_8321_8322 8321 8322 4.356752e+00
R_8322_8323 8322 8323 5.078427e+00
R_8323_8324 8323 8324 9.679663e+00
R_8324_8325 8324 8325 1.898870e+00
R_8325_8326 8325 8326 5.979915e+00
R_8326_8327 8326 8327 8.550998e+00
R_8327_8328 8327 8328 2.370215e+00
R_8328_8329 8328 8329 5.975281e+00
R_8329_8330 8329 8330 1.138855e+00
R_8330_8331 8330 8331 9.688056e+00
R_8331_8332 8331 8332 8.713892e+00
R_8332_8333 8332 8333 3.903558e+00
R_8333_8334 8333 8334 4.194476e+00
R_8334_8335 8334 8335 3.421388e+00
R_8335_8336 8335 8336 2.689617e+00
R_8336_8337 8336 8337 4.761151e+00
R_8337_8338 8337 8338 9.405763e+00
R_8338_8339 8338 8339 9.571608e+00
R_8339_8340 8339 8340 2.846042e+00
R_8340_8341 8340 8341 8.448824e+00
R_8341_8342 8341 8342 9.254053e+00
R_8342_8343 8342 8343 1.360890e+00
R_8343_8344 8343 8344 5.157195e+00
R_8344_8345 8344 8345 5.762501e+00
R_8345_8346 8345 8346 2.914115e+00
R_8346_8347 8346 8347 4.613202e+00
R_8347_8348 8347 8348 4.091988e+00
R_8348_8349 8348 8349 9.053977e+00
R_8349_8350 8349 8350 5.697682e+00
R_8350_8351 8350 8351 6.680001e+00
R_8351_8352 8351 8352 1.565706e+00
R_8352_8353 8352 8353 5.048062e+00
R_8353_8354 8353 8354 1.247788e+00
R_8354_8355 8354 8355 4.643139e+00
R_8355_8356 8355 8356 5.775154e+00
R_8356_8357 8356 8357 6.477395e+00
R_8357_8358 8357 8358 4.330891e+00
R_8358_8359 8358 8359 5.177949e+00
R_8359_8360 8359 8360 1.786369e+00
R_8360_8361 8360 8361 5.640239e+00
R_8361_8362 8361 8362 5.562403e+00
R_8362_8363 8362 8363 8.284914e+00
R_8363_8364 8363 8364 3.382559e+00
R_8364_8365 8364 8365 3.636604e+00
R_8365_8366 8365 8366 9.866366e+00
R_8366_8367 8366 8367 1.765798e+00
R_8367_8368 8367 8368 6.626956e+00
R_8368_8369 8368 8369 2.919986e+00
R_8369_8370 8369 8370 2.943526e+00
R_8370_8371 8370 8371 6.031961e+00
R_8371_8372 8371 8372 6.437255e+00
R_8372_8373 8372 8373 5.344848e+00
R_8373_8374 8373 8374 8.239786e+00
R_8374_8375 8374 8375 5.497497e+00
R_8375_8376 8375 8376 9.249017e-01
R_8376_8377 8376 8377 6.629767e+00
R_8377_8378 8377 8378 4.544397e+00
R_8378_8379 8378 8379 3.505436e+00
R_8379_8380 8379 8380 3.762859e+00
R_8380_8381 8380 8381 6.449571e+00
R_8381_8382 8381 8382 5.547484e+00
R_8382_8383 8382 8383 9.554083e-01
R_8383_8384 8383 8384 2.336359e+00
R_8384_8385 8384 8385 2.126724e+00
R_8385_8386 8385 8386 4.585275e+00
R_8386_8387 8386 8387 5.644238e+00
R_8387_8388 8387 8388 2.768489e+00
R_8388_8389 8388 8389 4.130756e+00
R_8389_8390 8389 8390 6.537598e+00
R_8390_8391 8390 8391 4.178898e+00
R_8391_8392 8391 8392 8.169450e+00
R_8392_8393 8392 8393 8.451517e-01
R_8393_8394 8393 8394 2.666938e+00
R_8394_8395 8394 8395 5.661026e+00
R_8395_8396 8395 8396 3.084082e+00
R_8396_8397 8396 8397 7.391778e+00
R_8397_8398 8397 8398 3.914118e-01
R_8398_8399 8398 8399 9.118340e+00
R_8399_8400 8399 8400 1.773939e+00
R_8401_8402 8401 8402 1.622562e+00
R_8402_8403 8402 8403 2.091726e+00
R_8403_8404 8403 8404 3.110414e+00
R_8404_8405 8404 8405 9.154877e-01
R_8405_8406 8405 8406 8.269523e+00
R_8406_8407 8406 8407 2.789405e+00
R_8407_8408 8407 8408 7.266932e+00
R_8408_8409 8408 8409 9.530878e+00
R_8409_8410 8409 8410 8.879819e+00
R_8410_8411 8410 8411 7.461902e+00
R_8411_8412 8411 8412 4.433849e+00
R_8412_8413 8412 8413 6.997521e+00
R_8413_8414 8413 8414 5.272401e-01
R_8414_8415 8414 8415 8.942454e-03
R_8415_8416 8415 8416 8.674039e+00
R_8416_8417 8416 8417 8.206280e+00
R_8417_8418 8417 8418 3.764828e+00
R_8418_8419 8418 8419 8.410341e+00
R_8419_8420 8419 8420 6.769947e+00
R_8420_8421 8420 8421 1.634993e+00
R_8421_8422 8421 8422 5.054308e+00
R_8422_8423 8422 8423 1.927881e+00
R_8423_8424 8423 8424 9.862736e+00
R_8424_8425 8424 8425 4.150033e+00
R_8425_8426 8425 8426 6.791231e+00
R_8426_8427 8426 8427 3.806611e+00
R_8427_8428 8427 8428 5.085978e+00
R_8428_8429 8428 8429 9.817352e+00
R_8429_8430 8429 8430 2.564178e+00
R_8430_8431 8430 8431 9.418405e+00
R_8431_8432 8431 8432 3.267467e+00
R_8432_8433 8432 8433 4.080663e+00
R_8433_8434 8433 8434 1.166338e+00
R_8434_8435 8434 8435 9.240471e-01
R_8435_8436 8435 8436 5.252237e+00
R_8436_8437 8436 8437 3.771101e+00
R_8437_8438 8437 8438 2.368832e+00
R_8438_8439 8438 8439 4.629858e-01
R_8439_8440 8439 8440 6.470733e+00
R_8440_8441 8440 8441 5.230198e+00
R_8441_8442 8441 8442 1.858408e+00
R_8442_8443 8442 8443 5.203645e+00
R_8443_8444 8443 8444 5.210905e+00
R_8444_8445 8444 8445 8.981975e+00
R_8445_8446 8445 8446 4.841973e+00
R_8446_8447 8446 8447 1.984003e+00
R_8447_8448 8447 8448 9.475577e+00
R_8448_8449 8448 8449 6.458031e+00
R_8449_8450 8449 8450 1.461804e+00
R_8450_8451 8450 8451 9.835740e+00
R_8451_8452 8451 8452 7.260832e+00
R_8452_8453 8452 8453 5.767013e+00
R_8453_8454 8453 8454 7.514396e+00
R_8454_8455 8454 8455 9.808554e+00
R_8455_8456 8455 8456 7.458153e+00
R_8456_8457 8456 8457 3.591693e+00
R_8457_8458 8457 8458 6.977434e+00
R_8458_8459 8458 8459 6.395413e+00
R_8459_8460 8459 8460 4.276371e+00
R_8460_8461 8460 8461 4.465209e+00
R_8461_8462 8461 8462 6.743486e+00
R_8462_8463 8462 8463 4.942187e+00
R_8463_8464 8463 8464 5.885677e+00
R_8464_8465 8464 8465 8.119601e+00
R_8465_8466 8465 8466 5.943393e+00
R_8466_8467 8466 8467 3.342008e+00
R_8467_8468 8467 8468 9.111697e-02
R_8468_8469 8468 8469 2.122929e+00
R_8469_8470 8469 8470 6.369772e+00
R_8470_8471 8470 8471 1.240776e+00
R_8471_8472 8471 8472 5.889864e+00
R_8472_8473 8472 8473 9.399697e+00
R_8473_8474 8473 8474 7.197464e+00
R_8474_8475 8474 8475 9.366803e+00
R_8475_8476 8475 8476 4.402890e+00
R_8476_8477 8476 8477 1.854468e+00
R_8477_8478 8477 8478 5.450691e+00
R_8478_8479 8478 8479 2.990160e+00
R_8479_8480 8479 8480 5.210269e+00
R_8480_8481 8480 8481 4.973936e+00
R_8481_8482 8481 8482 6.441427e+00
R_8482_8483 8482 8483 4.715917e-01
R_8483_8484 8483 8484 7.217983e+00
R_8484_8485 8484 8485 5.062272e+00
R_8485_8486 8485 8486 8.298780e+00
R_8486_8487 8486 8487 5.935021e+00
R_8487_8488 8487 8488 5.565914e+00
R_8488_8489 8488 8489 7.760241e+00
R_8489_8490 8489 8490 6.934709e+00
R_8490_8491 8490 8491 8.239326e+00
R_8491_8492 8491 8492 2.947886e-01
R_8492_8493 8492 8493 5.324088e+00
R_8493_8494 8493 8494 4.670239e+00
R_8494_8495 8494 8495 2.036993e+00
R_8495_8496 8495 8496 1.031766e+00
R_8496_8497 8496 8497 8.855464e+00
R_8497_8498 8497 8498 7.773814e+00
R_8498_8499 8498 8499 3.390255e+00
R_8499_8500 8499 8500 3.719071e+00
R_8501_8502 8501 8502 2.436397e+00
R_8502_8503 8502 8503 4.436072e+00
R_8503_8504 8503 8504 2.394653e+00
R_8504_8505 8504 8505 5.320924e+00
R_8505_8506 8505 8506 4.329482e+00
R_8506_8507 8506 8507 1.888226e-01
R_8507_8508 8507 8508 7.233142e-02
R_8508_8509 8508 8509 6.547901e-01
R_8509_8510 8509 8510 5.884393e+00
R_8510_8511 8510 8511 2.446376e+00
R_8511_8512 8511 8512 6.775823e+00
R_8512_8513 8512 8513 1.256077e+00
R_8513_8514 8513 8514 3.663077e+00
R_8514_8515 8514 8515 5.208872e+00
R_8515_8516 8515 8516 7.781789e+00
R_8516_8517 8516 8517 3.116764e-01
R_8517_8518 8517 8518 3.808391e+00
R_8518_8519 8518 8519 5.123829e+00
R_8519_8520 8519 8520 6.836561e-01
R_8520_8521 8520 8521 8.441191e+00
R_8521_8522 8521 8522 6.800894e+00
R_8522_8523 8522 8523 6.543488e+00
R_8523_8524 8523 8524 5.152206e+00
R_8524_8525 8524 8525 8.946428e+00
R_8525_8526 8525 8526 1.028423e+00
R_8526_8527 8526 8527 5.390099e+00
R_8527_8528 8527 8528 7.944854e+00
R_8528_8529 8528 8529 3.567375e+00
R_8529_8530 8529 8530 7.017892e+00
R_8530_8531 8530 8531 1.594796e+00
R_8531_8532 8531 8532 3.874453e+00
R_8532_8533 8532 8533 4.737603e+00
R_8533_8534 8533 8534 9.194031e+00
R_8534_8535 8534 8535 5.185966e+00
R_8535_8536 8535 8536 9.343485e+00
R_8536_8537 8536 8537 6.287904e+00
R_8537_8538 8537 8538 4.032496e+00
R_8538_8539 8538 8539 1.114069e+00
R_8539_8540 8539 8540 2.406826e+00
R_8540_8541 8540 8541 4.181573e+00
R_8541_8542 8541 8542 5.827163e+00
R_8542_8543 8542 8543 9.184840e+00
R_8543_8544 8543 8544 4.197809e-01
R_8544_8545 8544 8545 5.261124e+00
R_8545_8546 8545 8546 8.356316e+00
R_8546_8547 8546 8547 9.720698e+00
R_8547_8548 8547 8548 5.875479e+00
R_8548_8549 8548 8549 8.493792e+00
R_8549_8550 8549 8550 4.303706e+00
R_8550_8551 8550 8551 1.853419e+00
R_8551_8552 8551 8552 8.429643e+00
R_8552_8553 8552 8553 1.076513e+00
R_8553_8554 8553 8554 9.119566e+00
R_8554_8555 8554 8555 4.927861e+00
R_8555_8556 8555 8556 3.895806e+00
R_8556_8557 8556 8557 9.469890e+00
R_8557_8558 8557 8558 6.089739e+00
R_8558_8559 8558 8559 3.796072e+00
R_8559_8560 8559 8560 4.309512e+00
R_8560_8561 8560 8561 2.643231e+00
R_8561_8562 8561 8562 4.372731e-01
R_8562_8563 8562 8563 5.084608e-01
R_8563_8564 8563 8564 3.539753e+00
R_8564_8565 8564 8565 4.386753e+00
R_8565_8566 8565 8566 5.523640e+00
R_8566_8567 8566 8567 8.147877e+00
R_8567_8568 8567 8568 1.398277e+00
R_8568_8569 8568 8569 4.300767e+00
R_8569_8570 8569 8570 6.647268e+00
R_8570_8571 8570 8571 6.744616e+00
R_8571_8572 8571 8572 8.147246e+00
R_8572_8573 8572 8573 9.640352e+00
R_8573_8574 8573 8574 6.576782e+00
R_8574_8575 8574 8575 6.820267e+00
R_8575_8576 8575 8576 5.508485e+00
R_8576_8577 8576 8577 1.480601e+00
R_8577_8578 8577 8578 5.032355e+00
R_8578_8579 8578 8579 3.346954e+00
R_8579_8580 8579 8580 1.131568e+00
R_8580_8581 8580 8581 5.088103e-01
R_8581_8582 8581 8582 8.024563e+00
R_8582_8583 8582 8583 5.219996e+00
R_8583_8584 8583 8584 9.621409e+00
R_8584_8585 8584 8585 5.646703e+00
R_8585_8586 8585 8586 5.413270e+00
R_8586_8587 8586 8587 8.854805e+00
R_8587_8588 8587 8588 5.094628e+00
R_8588_8589 8588 8589 4.468454e+00
R_8589_8590 8589 8590 2.974611e+00
R_8590_8591 8590 8591 6.966131e-01
R_8591_8592 8591 8592 3.174409e+00
R_8592_8593 8592 8593 3.313716e+00
R_8593_8594 8593 8594 5.971879e+00
R_8594_8595 8594 8595 9.688731e+00
R_8595_8596 8595 8596 8.196113e+00
R_8596_8597 8596 8597 4.581231e+00
R_8597_8598 8597 8598 4.914176e-01
R_8598_8599 8598 8599 4.780621e+00
R_8599_8600 8599 8600 6.048260e-02
R_8601_8602 8601 8602 5.923495e+00
R_8602_8603 8602 8603 2.564439e+00
R_8603_8604 8603 8604 9.028751e+00
R_8604_8605 8604 8605 1.693818e+00
R_8605_8606 8605 8606 8.956618e+00
R_8606_8607 8606 8607 6.129710e+00
R_8607_8608 8607 8608 7.793690e+00
R_8608_8609 8608 8609 6.846440e+00
R_8609_8610 8609 8610 2.584836e+00
R_8610_8611 8610 8611 6.844715e+00
R_8611_8612 8611 8612 3.889170e+00
R_8612_8613 8612 8613 1.811600e+00
R_8613_8614 8613 8614 2.304178e+00
R_8614_8615 8614 8615 7.765484e+00
R_8615_8616 8615 8616 4.361431e+00
R_8616_8617 8616 8617 9.942583e+00
R_8617_8618 8617 8618 1.367717e+00
R_8618_8619 8618 8619 9.323301e+00
R_8619_8620 8619 8620 5.520694e+00
R_8620_8621 8620 8621 1.713912e-01
R_8621_8622 8621 8622 2.966461e+00
R_8622_8623 8622 8623 4.582411e+00
R_8623_8624 8623 8624 7.200830e-01
R_8624_8625 8624 8625 2.767563e+00
R_8625_8626 8625 8626 5.672083e+00
R_8626_8627 8626 8627 9.417869e+00
R_8627_8628 8627 8628 7.359251e+00
R_8628_8629 8628 8629 1.693662e+00
R_8629_8630 8629 8630 2.680984e+00
R_8630_8631 8630 8631 8.748128e+00
R_8631_8632 8631 8632 6.443895e+00
R_8632_8633 8632 8633 5.825850e+00
R_8633_8634 8633 8634 1.228650e+00
R_8634_8635 8634 8635 2.961221e+00
R_8635_8636 8635 8636 4.755799e+00
R_8636_8637 8636 8637 8.708766e-02
R_8637_8638 8637 8638 3.397587e+00
R_8638_8639 8638 8639 1.060317e+00
R_8639_8640 8639 8640 1.468454e+00
R_8640_8641 8640 8641 3.468500e+00
R_8641_8642 8641 8642 8.484082e-01
R_8642_8643 8642 8643 9.897358e+00
R_8643_8644 8643 8644 3.408982e+00
R_8644_8645 8644 8645 2.057224e+00
R_8645_8646 8645 8646 9.905143e-01
R_8646_8647 8646 8647 2.190996e+00
R_8647_8648 8647 8648 4.649778e+00
R_8648_8649 8648 8649 1.549602e+00
R_8649_8650 8649 8650 8.791806e+00
R_8650_8651 8650 8651 2.276500e+00
R_8651_8652 8651 8652 1.848376e+00
R_8652_8653 8652 8653 4.106168e+00
R_8653_8654 8653 8654 9.489801e+00
R_8654_8655 8654 8655 4.433160e+00
R_8655_8656 8655 8656 6.769607e-01
R_8656_8657 8656 8657 3.135230e+00
R_8657_8658 8657 8658 2.602657e+00
R_8658_8659 8658 8659 4.023029e+00
R_8659_8660 8659 8660 1.737833e+00
R_8660_8661 8660 8661 8.169338e+00
R_8661_8662 8661 8662 1.638968e+00
R_8662_8663 8662 8663 5.400174e-02
R_8663_8664 8663 8664 1.848972e+00
R_8664_8665 8664 8665 8.018520e+00
R_8665_8666 8665 8666 4.280742e+00
R_8666_8667 8666 8667 2.150597e+00
R_8667_8668 8667 8668 1.180099e+00
R_8668_8669 8668 8669 8.191894e+00
R_8669_8670 8669 8670 6.354912e+00
R_8670_8671 8670 8671 6.518231e+00
R_8671_8672 8671 8672 3.225209e+00
R_8672_8673 8672 8673 1.840922e+00
R_8673_8674 8673 8674 8.603207e+00
R_8674_8675 8674 8675 3.942277e+00
R_8675_8676 8675 8676 1.019436e+00
R_8676_8677 8676 8677 4.808435e+00
R_8677_8678 8677 8678 6.419519e-01
R_8678_8679 8678 8679 3.498924e+00
R_8679_8680 8679 8680 3.398462e+00
R_8680_8681 8680 8681 5.883492e+00
R_8681_8682 8681 8682 3.882390e+00
R_8682_8683 8682 8683 9.367211e+00
R_8683_8684 8683 8684 2.182203e+00
R_8684_8685 8684 8685 6.072630e+00
R_8685_8686 8685 8686 1.109922e+00
R_8686_8687 8686 8687 7.377270e+00
R_8687_8688 8687 8688 4.344596e-01
R_8688_8689 8688 8689 4.276258e+00
R_8689_8690 8689 8690 1.053631e+00
R_8690_8691 8690 8691 9.018870e+00
R_8691_8692 8691 8692 9.205914e+00
R_8692_8693 8692 8693 3.512300e+00
R_8693_8694 8693 8694 6.758258e+00
R_8694_8695 8694 8695 1.785422e+00
R_8695_8696 8695 8696 7.305032e+00
R_8696_8697 8696 8697 9.424705e+00
R_8697_8698 8697 8698 2.774221e+00
R_8698_8699 8698 8699 6.915555e-01
R_8699_8700 8699 8700 2.607676e+00
R_8701_8702 8701 8702 4.704470e+00
R_8702_8703 8702 8703 1.793205e-01
R_8703_8704 8703 8704 5.453923e+00
R_8704_8705 8704 8705 8.830436e+00
R_8705_8706 8705 8706 4.375280e+00
R_8706_8707 8706 8707 6.791324e+00
R_8707_8708 8707 8708 1.900385e+00
R_8708_8709 8708 8709 2.762781e+00
R_8709_8710 8709 8710 7.245001e+00
R_8710_8711 8710 8711 4.149949e+00
R_8711_8712 8711 8712 4.055667e+00
R_8712_8713 8712 8713 8.455138e+00
R_8713_8714 8713 8714 7.920512e+00
R_8714_8715 8714 8715 8.286619e+00
R_8715_8716 8715 8716 6.843378e-02
R_8716_8717 8716 8717 7.040584e+00
R_8717_8718 8717 8718 8.075128e+00
R_8718_8719 8718 8719 9.076579e+00
R_8719_8720 8719 8720 2.735588e+00
R_8720_8721 8720 8721 2.181170e+00
R_8721_8722 8721 8722 8.557280e+00
R_8722_8723 8722 8723 5.533322e-01
R_8723_8724 8723 8724 6.761305e+00
R_8724_8725 8724 8725 6.891946e-01
R_8725_8726 8725 8726 2.008968e-01
R_8726_8727 8726 8727 4.969181e+00
R_8727_8728 8727 8728 1.369125e+00
R_8728_8729 8728 8729 3.026376e+00
R_8729_8730 8729 8730 7.002429e+00
R_8730_8731 8730 8731 9.172125e-01
R_8731_8732 8731 8732 9.953078e+00
R_8732_8733 8732 8733 3.379768e+00
R_8733_8734 8733 8734 5.392519e+00
R_8734_8735 8734 8735 6.117529e+00
R_8735_8736 8735 8736 7.335533e+00
R_8736_8737 8736 8737 2.676346e+00
R_8737_8738 8737 8738 9.818160e+00
R_8738_8739 8738 8739 8.244147e+00
R_8739_8740 8739 8740 6.788575e+00
R_8740_8741 8740 8741 8.757017e+00
R_8741_8742 8741 8742 8.929449e+00
R_8742_8743 8742 8743 7.769123e+00
R_8743_8744 8743 8744 1.839035e+00
R_8744_8745 8744 8745 7.773043e+00
R_8745_8746 8745 8746 2.838995e+00
R_8746_8747 8746 8747 6.509692e+00
R_8747_8748 8747 8748 9.642840e+00
R_8748_8749 8748 8749 9.567145e+00
R_8749_8750 8749 8750 5.622096e+00
R_8750_8751 8750 8751 3.759459e+00
R_8751_8752 8751 8752 6.564899e+00
R_8752_8753 8752 8753 4.799341e+00
R_8753_8754 8753 8754 5.201409e+00
R_8754_8755 8754 8755 5.897977e+00
R_8755_8756 8755 8756 7.804150e+00
R_8756_8757 8756 8757 8.356963e+00
R_8757_8758 8757 8758 4.342543e+00
R_8758_8759 8758 8759 9.686620e+00
R_8759_8760 8759 8760 2.462629e+00
R_8760_8761 8760 8761 2.228965e+00
R_8761_8762 8761 8762 1.359273e+00
R_8762_8763 8762 8763 7.458089e-01
R_8763_8764 8763 8764 4.987850e+00
R_8764_8765 8764 8765 9.757538e+00
R_8765_8766 8765 8766 3.539779e+00
R_8766_8767 8766 8767 1.599459e-01
R_8767_8768 8767 8768 5.209865e-01
R_8768_8769 8768 8769 5.215648e+00
R_8769_8770 8769 8770 9.458142e+00
R_8770_8771 8770 8771 9.469489e-01
R_8771_8772 8771 8772 8.288692e-01
R_8772_8773 8772 8773 2.063790e+00
R_8773_8774 8773 8774 5.821975e+00
R_8774_8775 8774 8775 6.722609e+00
R_8775_8776 8775 8776 7.680727e+00
R_8776_8777 8776 8777 7.315243e+00
R_8777_8778 8777 8778 5.436697e+00
R_8778_8779 8778 8779 5.624904e+00
R_8779_8780 8779 8780 3.884675e+00
R_8780_8781 8780 8781 3.166278e-01
R_8781_8782 8781 8782 3.938062e+00
R_8782_8783 8782 8783 8.030821e+00
R_8783_8784 8783 8784 8.183785e+00
R_8784_8785 8784 8785 7.291277e+00
R_8785_8786 8785 8786 2.683872e+00
R_8786_8787 8786 8787 9.813072e+00
R_8787_8788 8787 8788 8.510943e+00
R_8788_8789 8788 8789 1.935330e+00
R_8789_8790 8789 8790 8.254149e-01
R_8790_8791 8790 8791 8.589368e+00
R_8791_8792 8791 8792 9.884380e+00
R_8792_8793 8792 8793 1.215667e+00
R_8793_8794 8793 8794 7.801375e+00
R_8794_8795 8794 8795 5.436040e+00
R_8795_8796 8795 8796 2.210209e+00
R_8796_8797 8796 8797 8.036594e-01
R_8797_8798 8797 8798 6.558896e+00
R_8798_8799 8798 8799 5.748587e+00
R_8799_8800 8799 8800 2.420468e+00
R_8801_8802 8801 8802 3.633875e+00
R_8802_8803 8802 8803 3.129468e+00
R_8803_8804 8803 8804 8.818271e+00
R_8804_8805 8804 8805 7.016110e+00
R_8805_8806 8805 8806 8.871760e+00
R_8806_8807 8806 8807 5.265073e+00
R_8807_8808 8807 8808 6.238521e+00
R_8808_8809 8808 8809 1.538343e+00
R_8809_8810 8809 8810 5.238968e+00
R_8810_8811 8810 8811 5.718565e+00
R_8811_8812 8811 8812 6.576879e-01
R_8812_8813 8812 8813 9.733228e+00
R_8813_8814 8813 8814 5.921613e+00
R_8814_8815 8814 8815 3.588427e+00
R_8815_8816 8815 8816 5.335153e+00
R_8816_8817 8816 8817 6.896275e+00
R_8817_8818 8817 8818 6.543753e+00
R_8818_8819 8818 8819 3.500033e+00
R_8819_8820 8819 8820 4.702722e+00
R_8820_8821 8820 8821 6.232268e+00
R_8821_8822 8821 8822 6.667560e+00
R_8822_8823 8822 8823 6.355767e+00
R_8823_8824 8823 8824 5.187959e+00
R_8824_8825 8824 8825 5.146692e-01
R_8825_8826 8825 8826 8.254445e+00
R_8826_8827 8826 8827 4.639830e+00
R_8827_8828 8827 8828 9.314501e-01
R_8828_8829 8828 8829 3.695096e+00
R_8829_8830 8829 8830 5.649361e+00
R_8830_8831 8830 8831 9.736776e+00
R_8831_8832 8831 8832 3.512024e+00
R_8832_8833 8832 8833 3.394730e+00
R_8833_8834 8833 8834 7.016082e+00
R_8834_8835 8834 8835 9.480911e+00
R_8835_8836 8835 8836 8.105392e+00
R_8836_8837 8836 8837 6.213134e+00
R_8837_8838 8837 8838 9.590565e+00
R_8838_8839 8838 8839 9.093033e+00
R_8839_8840 8839 8840 7.353044e+00
R_8840_8841 8840 8841 9.742274e+00
R_8841_8842 8841 8842 8.499129e+00
R_8842_8843 8842 8843 5.259463e+00
R_8843_8844 8843 8844 3.597745e+00
R_8844_8845 8844 8845 9.763560e+00
R_8845_8846 8845 8846 8.419984e-01
R_8846_8847 8846 8847 5.954410e+00
R_8847_8848 8847 8848 5.595507e+00
R_8848_8849 8848 8849 7.076835e+00
R_8849_8850 8849 8850 4.074439e+00
R_8850_8851 8850 8851 5.728463e+00
R_8851_8852 8851 8852 4.550757e+00
R_8852_8853 8852 8853 3.739616e+00
R_8853_8854 8853 8854 8.395836e-02
R_8854_8855 8854 8855 9.485180e+00
R_8855_8856 8855 8856 8.648918e+00
R_8856_8857 8856 8857 8.770616e+00
R_8857_8858 8857 8858 9.088565e+00
R_8858_8859 8858 8859 2.168244e+00
R_8859_8860 8859 8860 6.417927e-01
R_8860_8861 8860 8861 7.318250e+00
R_8861_8862 8861 8862 7.886008e+00
R_8862_8863 8862 8863 3.795118e+00
R_8863_8864 8863 8864 9.395238e-01
R_8864_8865 8864 8865 6.212502e-01
R_8865_8866 8865 8866 1.927661e+00
R_8866_8867 8866 8867 1.128272e+00
R_8867_8868 8867 8868 3.566706e+00
R_8868_8869 8868 8869 2.677694e+00
R_8869_8870 8869 8870 7.846103e+00
R_8870_8871 8870 8871 6.986100e+00
R_8871_8872 8871 8872 1.138597e+00
R_8872_8873 8872 8873 7.466039e+00
R_8873_8874 8873 8874 7.882657e+00
R_8874_8875 8874 8875 9.543214e-01
R_8875_8876 8875 8876 6.757953e+00
R_8876_8877 8876 8877 7.703165e+00
R_8877_8878 8877 8878 3.839423e+00
R_8878_8879 8878 8879 1.341688e-01
R_8879_8880 8879 8880 6.494298e+00
R_8880_8881 8880 8881 2.070967e+00
R_8881_8882 8881 8882 5.366898e+00
R_8882_8883 8882 8883 1.998339e-02
R_8883_8884 8883 8884 2.087890e+00
R_8884_8885 8884 8885 5.609793e+00
R_8885_8886 8885 8886 1.824533e+00
R_8886_8887 8886 8887 1.047283e+00
R_8887_8888 8887 8888 4.811796e-01
R_8888_8889 8888 8889 8.284114e+00
R_8889_8890 8889 8890 9.284920e+00
R_8890_8891 8890 8891 8.042939e+00
R_8891_8892 8891 8892 6.572374e+00
R_8892_8893 8892 8893 3.764918e+00
R_8893_8894 8893 8894 4.889170e+00
R_8894_8895 8894 8895 1.940079e+00
R_8895_8896 8895 8896 4.949704e+00
R_8896_8897 8896 8897 9.821920e+00
R_8897_8898 8897 8898 2.682292e+00
R_8898_8899 8898 8899 2.335798e+00
R_8899_8900 8899 8900 7.341714e+00
R_8901_8902 8901 8902 7.670003e+00
R_8902_8903 8902 8903 7.926363e+00
R_8903_8904 8903 8904 9.328627e+00
R_8904_8905 8904 8905 1.845174e+00
R_8905_8906 8905 8906 1.134969e+00
R_8906_8907 8906 8907 7.470958e+00
R_8907_8908 8907 8908 1.375065e+00
R_8908_8909 8908 8909 9.433175e-01
R_8909_8910 8909 8910 1.877486e-01
R_8910_8911 8910 8911 5.358206e-01
R_8911_8912 8911 8912 2.871923e+00
R_8912_8913 8912 8913 4.250066e-01
R_8913_8914 8913 8914 4.041740e+00
R_8914_8915 8914 8915 4.307613e+00
R_8915_8916 8915 8916 8.099011e+00
R_8916_8917 8916 8917 4.221156e+00
R_8917_8918 8917 8918 1.604558e-01
R_8918_8919 8918 8919 7.371285e+00
R_8919_8920 8919 8920 7.292950e+00
R_8920_8921 8920 8921 5.759788e+00
R_8921_8922 8921 8922 5.149929e+00
R_8922_8923 8922 8923 1.715946e+00
R_8923_8924 8923 8924 1.559042e+00
R_8924_8925 8924 8925 2.081563e+00
R_8925_8926 8925 8926 1.944343e+00
R_8926_8927 8926 8927 1.528116e+00
R_8927_8928 8927 8928 5.624842e+00
R_8928_8929 8928 8929 9.025559e+00
R_8929_8930 8929 8930 4.162855e+00
R_8930_8931 8930 8931 6.195231e+00
R_8931_8932 8931 8932 5.821985e+00
R_8932_8933 8932 8933 1.560582e+00
R_8933_8934 8933 8934 9.877935e+00
R_8934_8935 8934 8935 7.271678e+00
R_8935_8936 8935 8936 4.160726e+00
R_8936_8937 8936 8937 2.552536e+00
R_8937_8938 8937 8938 5.652790e-01
R_8938_8939 8938 8939 8.229130e+00
R_8939_8940 8939 8940 6.072663e+00
R_8940_8941 8940 8941 8.203673e+00
R_8941_8942 8941 8942 2.871861e+00
R_8942_8943 8942 8943 1.980762e+00
R_8943_8944 8943 8944 9.525731e+00
R_8944_8945 8944 8945 9.182334e+00
R_8945_8946 8945 8946 8.075356e+00
R_8946_8947 8946 8947 8.948196e+00
R_8947_8948 8947 8948 6.339513e+00
R_8948_8949 8948 8949 7.517622e+00
R_8949_8950 8949 8950 4.567232e+00
R_8950_8951 8950 8951 5.149876e+00
R_8951_8952 8951 8952 6.404352e+00
R_8952_8953 8952 8953 1.816850e+00
R_8953_8954 8953 8954 1.246168e-01
R_8954_8955 8954 8955 9.877559e+00
R_8955_8956 8955 8956 9.913915e-02
R_8956_8957 8956 8957 6.186613e+00
R_8957_8958 8957 8958 8.795378e+00
R_8958_8959 8958 8959 4.916464e+00
R_8959_8960 8959 8960 2.170282e+00
R_8960_8961 8960 8961 2.572039e+00
R_8961_8962 8961 8962 1.513244e+00
R_8962_8963 8962 8963 6.658802e-01
R_8963_8964 8963 8964 7.626644e-01
R_8964_8965 8964 8965 3.901316e+00
R_8965_8966 8965 8966 4.582560e+00
R_8966_8967 8966 8967 6.017285e+00
R_8967_8968 8967 8968 6.744348e+00
R_8968_8969 8968 8969 7.049708e+00
R_8969_8970 8969 8970 7.972296e+00
R_8970_8971 8970 8971 8.756489e+00
R_8971_8972 8971 8972 4.835423e+00
R_8972_8973 8972 8973 3.829515e+00
R_8973_8974 8973 8974 1.235522e+00
R_8974_8975 8974 8975 7.976057e+00
R_8975_8976 8975 8976 1.621678e+00
R_8976_8977 8976 8977 7.072079e+00
R_8977_8978 8977 8978 5.251528e+00
R_8978_8979 8978 8979 2.420473e-01
R_8979_8980 8979 8980 1.575959e+00
R_8980_8981 8980 8981 3.800690e-01
R_8981_8982 8981 8982 7.520741e+00
R_8982_8983 8982 8983 3.791267e+00
R_8983_8984 8983 8984 5.161507e+00
R_8984_8985 8984 8985 2.498054e+00
R_8985_8986 8985 8986 3.543288e+00
R_8986_8987 8986 8987 3.885089e-01
R_8987_8988 8987 8988 6.709201e+00
R_8988_8989 8988 8989 1.010056e+00
R_8989_8990 8989 8990 4.927677e+00
R_8990_8991 8990 8991 3.635539e+00
R_8991_8992 8991 8992 1.769292e+00
R_8992_8993 8992 8993 9.836914e-02
R_8993_8994 8993 8994 2.709966e-01
R_8994_8995 8994 8995 2.577569e+00
R_8995_8996 8995 8996 9.522023e+00
R_8996_8997 8996 8997 2.467200e+00
R_8997_8998 8997 8998 5.341162e+00
R_8998_8999 8998 8999 6.471678e+00
R_8999_9000 8999 9000 4.116200e+00
R_9001_9002 9001 9002 2.028205e+00
R_9002_9003 9002 9003 4.529524e+00
R_9003_9004 9003 9004 2.544151e+00
R_9004_9005 9004 9005 4.619588e-01
R_9005_9006 9005 9006 7.037763e+00
R_9006_9007 9006 9007 9.421166e+00
R_9007_9008 9007 9008 8.902540e+00
R_9008_9009 9008 9009 5.734186e+00
R_9009_9010 9009 9010 9.804252e+00
R_9010_9011 9010 9011 8.372393e+00
R_9011_9012 9011 9012 6.031984e+00
R_9012_9013 9012 9013 8.063811e-01
R_9013_9014 9013 9014 8.630021e+00
R_9014_9015 9014 9015 8.220123e+00
R_9015_9016 9015 9016 7.080613e-01
R_9016_9017 9016 9017 9.420431e+00
R_9017_9018 9017 9018 2.285428e+00
R_9018_9019 9018 9019 7.040830e+00
R_9019_9020 9019 9020 2.172015e+00
R_9020_9021 9020 9021 6.456399e+00
R_9021_9022 9021 9022 1.758074e+00
R_9022_9023 9022 9023 7.337494e+00
R_9023_9024 9023 9024 5.267296e+00
R_9024_9025 9024 9025 1.298681e+00
R_9025_9026 9025 9026 9.612561e-01
R_9026_9027 9026 9027 2.458707e+00
R_9027_9028 9027 9028 4.453779e+00
R_9028_9029 9028 9029 5.288904e-01
R_9029_9030 9029 9030 7.180987e+00
R_9030_9031 9030 9031 1.097839e+00
R_9031_9032 9031 9032 5.388247e+00
R_9032_9033 9032 9033 1.856655e+00
R_9033_9034 9033 9034 3.483089e+00
R_9034_9035 9034 9035 3.463306e+00
R_9035_9036 9035 9036 6.387336e+00
R_9036_9037 9036 9037 6.133677e+00
R_9037_9038 9037 9038 2.818567e+00
R_9038_9039 9038 9039 6.362605e+00
R_9039_9040 9039 9040 7.517834e+00
R_9040_9041 9040 9041 4.963623e+00
R_9041_9042 9041 9042 2.785245e+00
R_9042_9043 9042 9043 8.202272e+00
R_9043_9044 9043 9044 1.290268e+00
R_9044_9045 9044 9045 9.624438e+00
R_9045_9046 9045 9046 4.167555e+00
R_9046_9047 9046 9047 4.850591e+00
R_9047_9048 9047 9048 3.399778e+00
R_9048_9049 9048 9049 3.784328e+00
R_9049_9050 9049 9050 9.030348e+00
R_9050_9051 9050 9051 5.679692e+00
R_9051_9052 9051 9052 2.890228e+00
R_9052_9053 9052 9053 1.597702e+00
R_9053_9054 9053 9054 6.132568e+00
R_9054_9055 9054 9055 8.903624e+00
R_9055_9056 9055 9056 7.108495e+00
R_9056_9057 9056 9057 5.100310e+00
R_9057_9058 9057 9058 2.859616e-01
R_9058_9059 9058 9059 5.887385e+00
R_9059_9060 9059 9060 3.036349e+00
R_9060_9061 9060 9061 6.267540e+00
R_9061_9062 9061 9062 6.089098e+00
R_9062_9063 9062 9063 8.462636e+00
R_9063_9064 9063 9064 5.773991e+00
R_9064_9065 9064 9065 7.119560e+00
R_9065_9066 9065 9066 1.726157e+00
R_9066_9067 9066 9067 3.273932e+00
R_9067_9068 9067 9068 7.165725e+00
R_9068_9069 9068 9069 4.288468e+00
R_9069_9070 9069 9070 9.721833e+00
R_9070_9071 9070 9071 7.847849e+00
R_9071_9072 9071 9072 1.047816e+00
R_9072_9073 9072 9073 4.310755e+00
R_9073_9074 9073 9074 8.598740e+00
R_9074_9075 9074 9075 9.641857e+00
R_9075_9076 9075 9076 4.319300e+00
R_9076_9077 9076 9077 8.143691e+00
R_9077_9078 9077 9078 8.702350e+00
R_9078_9079 9078 9079 8.849423e+00
R_9079_9080 9079 9080 4.060489e+00
R_9080_9081 9080 9081 9.963814e+00
R_9081_9082 9081 9082 6.316486e-01
R_9082_9083 9082 9083 7.201972e+00
R_9083_9084 9083 9084 4.645834e+00
R_9084_9085 9084 9085 2.083955e-02
R_9085_9086 9085 9086 1.383339e+00
R_9086_9087 9086 9087 4.902327e+00
R_9087_9088 9087 9088 1.245765e+00
R_9088_9089 9088 9089 5.363100e+00
R_9089_9090 9089 9090 7.646251e+00
R_9090_9091 9090 9091 1.406383e+00
R_9091_9092 9091 9092 8.472684e+00
R_9092_9093 9092 9093 7.776946e+00
R_9093_9094 9093 9094 8.216238e+00
R_9094_9095 9094 9095 3.121981e+00
R_9095_9096 9095 9096 6.472797e+00
R_9096_9097 9096 9097 9.181964e+00
R_9097_9098 9097 9098 1.216994e+00
R_9098_9099 9098 9099 7.856731e-01
R_9099_9100 9099 9100 6.307333e+00
R_9101_9102 9101 9102 3.958287e+00
R_9102_9103 9102 9103 4.604864e+00
R_9103_9104 9103 9104 1.934149e+00
R_9104_9105 9104 9105 5.176938e+00
R_9105_9106 9105 9106 6.019981e+00
R_9106_9107 9106 9107 5.304101e+00
R_9107_9108 9107 9108 5.825361e+00
R_9108_9109 9108 9109 1.505640e+00
R_9109_9110 9109 9110 4.464712e+00
R_9110_9111 9110 9111 9.703547e+00
R_9111_9112 9111 9112 2.401356e+00
R_9112_9113 9112 9113 5.940354e+00
R_9113_9114 9113 9114 8.597930e+00
R_9114_9115 9114 9115 3.315609e+00
R_9115_9116 9115 9116 6.495706e+00
R_9116_9117 9116 9117 2.330080e-01
R_9117_9118 9117 9118 4.040301e-01
R_9118_9119 9118 9119 2.218633e+00
R_9119_9120 9119 9120 7.274926e-02
R_9120_9121 9120 9121 1.002613e-01
R_9121_9122 9121 9122 3.540838e+00
R_9122_9123 9122 9123 3.720610e+00
R_9123_9124 9123 9124 8.612211e+00
R_9124_9125 9124 9125 9.388277e+00
R_9125_9126 9125 9126 2.502344e+00
R_9126_9127 9126 9127 2.717631e+00
R_9127_9128 9127 9128 9.309406e+00
R_9128_9129 9128 9129 5.430860e-01
R_9129_9130 9129 9130 6.620924e+00
R_9130_9131 9130 9131 2.987066e+00
R_9131_9132 9131 9132 1.181302e+00
R_9132_9133 9132 9133 6.090605e+00
R_9133_9134 9133 9134 7.244819e+00
R_9134_9135 9134 9135 1.750912e+00
R_9135_9136 9135 9136 4.250109e+00
R_9136_9137 9136 9137 4.991185e+00
R_9137_9138 9137 9138 7.907576e+00
R_9138_9139 9138 9139 8.071318e-01
R_9139_9140 9139 9140 9.835671e+00
R_9140_9141 9140 9141 3.999286e+00
R_9141_9142 9141 9142 9.678855e+00
R_9142_9143 9142 9143 1.506728e+00
R_9143_9144 9143 9144 5.721937e+00
R_9144_9145 9144 9145 1.170880e+00
R_9145_9146 9145 9146 8.701904e+00
R_9146_9147 9146 9147 9.684374e+00
R_9147_9148 9147 9148 4.423139e-01
R_9148_9149 9148 9149 1.123765e-01
R_9149_9150 9149 9150 3.467811e+00
R_9150_9151 9150 9151 3.764820e+00
R_9151_9152 9151 9152 9.130871e-01
R_9152_9153 9152 9153 5.298797e+00
R_9153_9154 9153 9154 4.277599e+00
R_9154_9155 9154 9155 6.348032e+00
R_9155_9156 9155 9156 9.499883e+00
R_9156_9157 9156 9157 8.415013e+00
R_9157_9158 9157 9158 5.349385e-01
R_9158_9159 9158 9159 2.198864e+00
R_9159_9160 9159 9160 2.556763e+00
R_9160_9161 9160 9161 2.595248e+00
R_9161_9162 9161 9162 7.883532e+00
R_9162_9163 9162 9163 8.272131e+00
R_9163_9164 9163 9164 2.167086e+00
R_9164_9165 9164 9165 9.199000e+00
R_9165_9166 9165 9166 3.695336e+00
R_9166_9167 9166 9167 4.160501e+00
R_9167_9168 9167 9168 6.745679e+00
R_9168_9169 9168 9169 2.717928e+00
R_9169_9170 9169 9170 7.185068e+00
R_9170_9171 9170 9171 8.481985e+00
R_9171_9172 9171 9172 5.168202e+00
R_9172_9173 9172 9173 8.013122e+00
R_9173_9174 9173 9174 4.221606e+00
R_9174_9175 9174 9175 6.165518e+00
R_9175_9176 9175 9176 1.126129e+00
R_9176_9177 9176 9177 5.904850e+00
R_9177_9178 9177 9178 2.960700e+00
R_9178_9179 9178 9179 9.181728e+00
R_9179_9180 9179 9180 4.338608e+00
R_9180_9181 9180 9181 5.959378e+00
R_9181_9182 9181 9182 9.064788e-01
R_9182_9183 9182 9183 4.920971e+00
R_9183_9184 9183 9184 4.919347e+00
R_9184_9185 9184 9185 5.676568e+00
R_9185_9186 9185 9186 3.571895e+00
R_9186_9187 9186 9187 5.975160e+00
R_9187_9188 9187 9188 6.966944e+00
R_9188_9189 9188 9189 7.204006e+00
R_9189_9190 9189 9190 9.982076e+00
R_9190_9191 9190 9191 4.248138e+00
R_9191_9192 9191 9192 8.734754e+00
R_9192_9193 9192 9193 2.934957e-01
R_9193_9194 9193 9194 6.839618e+00
R_9194_9195 9194 9195 4.943756e+00
R_9195_9196 9195 9196 2.074112e+00
R_9196_9197 9196 9197 1.698762e+00
R_9197_9198 9197 9198 7.195783e+00
R_9198_9199 9198 9199 2.892831e+00
R_9199_9200 9199 9200 3.639082e+00
R_9201_9202 9201 9202 3.569617e+00
R_9202_9203 9202 9203 9.990985e+00
R_9203_9204 9203 9204 3.734509e+00
R_9204_9205 9204 9205 7.898891e+00
R_9205_9206 9205 9206 8.535330e+00
R_9206_9207 9206 9207 4.505177e+00
R_9207_9208 9207 9208 7.746718e+00
R_9208_9209 9208 9209 9.417470e+00
R_9209_9210 9209 9210 4.153573e+00
R_9210_9211 9210 9211 4.276312e+00
R_9211_9212 9211 9212 1.764989e-01
R_9212_9213 9212 9213 3.006455e+00
R_9213_9214 9213 9214 6.493043e+00
R_9214_9215 9214 9215 9.006753e-01
R_9215_9216 9215 9216 9.330896e+00
R_9216_9217 9216 9217 1.479193e+00
R_9217_9218 9217 9218 9.462432e+00
R_9218_9219 9218 9219 6.173084e+00
R_9219_9220 9219 9220 3.211482e+00
R_9220_9221 9220 9221 8.114542e+00
R_9221_9222 9221 9222 8.550324e+00
R_9222_9223 9222 9223 7.039585e-02
R_9223_9224 9223 9224 5.213985e+00
R_9224_9225 9224 9225 2.013792e+00
R_9225_9226 9225 9226 7.726787e+00
R_9226_9227 9226 9227 9.064951e+00
R_9227_9228 9227 9228 2.474449e+00
R_9228_9229 9228 9229 1.955854e+00
R_9229_9230 9229 9230 1.849161e+00
R_9230_9231 9230 9231 6.141956e+00
R_9231_9232 9231 9232 8.863671e-01
R_9232_9233 9232 9233 7.151385e+00
R_9233_9234 9233 9234 7.634683e+00
R_9234_9235 9234 9235 4.292079e+00
R_9235_9236 9235 9236 4.799206e+00
R_9236_9237 9236 9237 7.545630e+00
R_9237_9238 9237 9238 7.115126e-02
R_9238_9239 9238 9239 6.364637e+00
R_9239_9240 9239 9240 2.834594e+00
R_9240_9241 9240 9241 1.295222e+00
R_9241_9242 9241 9242 6.718927e+00
R_9242_9243 9242 9243 9.641015e+00
R_9243_9244 9243 9244 6.859834e+00
R_9244_9245 9244 9245 2.748985e+00
R_9245_9246 9245 9246 3.088176e+00
R_9246_9247 9246 9247 3.272794e+00
R_9247_9248 9247 9248 9.620061e+00
R_9248_9249 9248 9249 8.572475e-01
R_9249_9250 9249 9250 9.183948e+00
R_9250_9251 9250 9251 2.688383e+00
R_9251_9252 9251 9252 6.861256e+00
R_9252_9253 9252 9253 4.151446e+00
R_9253_9254 9253 9254 8.452472e+00
R_9254_9255 9254 9255 8.670371e+00
R_9255_9256 9255 9256 1.148964e+00
R_9256_9257 9256 9257 5.863467e+00
R_9257_9258 9257 9258 1.757521e+00
R_9258_9259 9258 9259 6.602990e+00
R_9259_9260 9259 9260 7.279063e+00
R_9260_9261 9260 9261 2.364535e+00
R_9261_9262 9261 9262 3.584877e+00
R_9262_9263 9262 9263 7.523407e+00
R_9263_9264 9263 9264 5.553836e+00
R_9264_9265 9264 9265 6.704698e+00
R_9265_9266 9265 9266 1.812660e+00
R_9266_9267 9266 9267 4.899576e+00
R_9267_9268 9267 9268 6.496094e+00
R_9268_9269 9268 9269 2.977813e+00
R_9269_9270 9269 9270 8.592516e+00
R_9270_9271 9270 9271 9.280435e+00
R_9271_9272 9271 9272 1.343590e+00
R_9272_9273 9272 9273 7.977032e+00
R_9273_9274 9273 9274 4.713988e+00
R_9274_9275 9274 9275 1.958419e+00
R_9275_9276 9275 9276 4.649565e+00
R_9276_9277 9276 9277 7.064558e+00
R_9277_9278 9277 9278 2.532225e+00
R_9278_9279 9278 9279 7.547289e+00
R_9279_9280 9279 9280 9.354049e-01
R_9280_9281 9280 9281 9.958113e+00
R_9281_9282 9281 9282 3.316213e+00
R_9282_9283 9282 9283 9.559813e+00
R_9283_9284 9283 9284 3.127849e+00
R_9284_9285 9284 9285 9.284630e+00
R_9285_9286 9285 9286 9.121813e+00
R_9286_9287 9286 9287 2.553098e+00
R_9287_9288 9287 9288 2.027725e+00
R_9288_9289 9288 9289 2.359142e+00
R_9289_9290 9289 9290 4.342709e+00
R_9290_9291 9290 9291 4.975310e+00
R_9291_9292 9291 9292 3.624722e+00
R_9292_9293 9292 9293 5.473594e+00
R_9293_9294 9293 9294 2.809688e+00
R_9294_9295 9294 9295 8.033026e+00
R_9295_9296 9295 9296 1.925709e+00
R_9296_9297 9296 9297 5.825825e-01
R_9297_9298 9297 9298 5.485068e-01
R_9298_9299 9298 9299 8.268651e+00
R_9299_9300 9299 9300 7.255069e+00
R_9301_9302 9301 9302 2.298904e+00
R_9302_9303 9302 9303 5.136056e+00
R_9303_9304 9303 9304 7.462513e+00
R_9304_9305 9304 9305 6.092183e+00
R_9305_9306 9305 9306 7.653256e+00
R_9306_9307 9306 9307 3.636646e+00
R_9307_9308 9307 9308 3.930338e+00
R_9308_9309 9308 9309 3.955554e+00
R_9309_9310 9309 9310 3.862017e+00
R_9310_9311 9310 9311 8.909441e-01
R_9311_9312 9311 9312 1.961003e+00
R_9312_9313 9312 9313 8.047430e+00
R_9313_9314 9313 9314 9.069751e+00
R_9314_9315 9314 9315 5.423632e+00
R_9315_9316 9315 9316 5.363746e-01
R_9316_9317 9316 9317 5.378135e+00
R_9317_9318 9317 9318 9.062888e-01
R_9318_9319 9318 9319 5.161243e+00
R_9319_9320 9319 9320 7.064395e+00
R_9320_9321 9320 9321 9.509385e+00
R_9321_9322 9321 9322 9.709840e+00
R_9322_9323 9322 9323 1.550524e+00
R_9323_9324 9323 9324 9.828853e+00
R_9324_9325 9324 9325 2.094856e+00
R_9325_9326 9325 9326 6.872906e+00
R_9326_9327 9326 9327 6.601307e+00
R_9327_9328 9327 9328 5.992901e+00
R_9328_9329 9328 9329 3.806517e+00
R_9329_9330 9329 9330 8.845418e+00
R_9330_9331 9330 9331 9.788322e+00
R_9331_9332 9331 9332 8.075191e+00
R_9332_9333 9332 9333 7.962521e+00
R_9333_9334 9333 9334 3.648282e+00
R_9334_9335 9334 9335 1.512536e+00
R_9335_9336 9335 9336 4.490989e+00
R_9336_9337 9336 9337 8.784122e+00
R_9337_9338 9337 9338 4.100000e+00
R_9338_9339 9338 9339 2.826829e-01
R_9339_9340 9339 9340 9.650527e-01
R_9340_9341 9340 9341 1.124508e+00
R_9341_9342 9341 9342 5.457161e+00
R_9342_9343 9342 9343 2.153496e+00
R_9343_9344 9343 9344 3.838182e+00
R_9344_9345 9344 9345 7.824865e+00
R_9345_9346 9345 9346 8.292529e+00
R_9346_9347 9346 9347 7.520543e+00
R_9347_9348 9347 9348 9.969355e+00
R_9348_9349 9348 9349 5.317898e+00
R_9349_9350 9349 9350 3.218682e+00
R_9350_9351 9350 9351 2.734317e+00
R_9351_9352 9351 9352 9.300971e+00
R_9352_9353 9352 9353 5.711715e+00
R_9353_9354 9353 9354 8.870338e+00
R_9354_9355 9354 9355 8.384748e+00
R_9355_9356 9355 9356 1.643685e+00
R_9356_9357 9356 9357 2.833946e+00
R_9357_9358 9357 9358 7.887257e+00
R_9358_9359 9358 9359 7.251498e-01
R_9359_9360 9359 9360 5.575429e+00
R_9360_9361 9360 9361 1.007497e-01
R_9361_9362 9361 9362 5.470027e+00
R_9362_9363 9362 9363 9.183065e+00
R_9363_9364 9363 9364 7.780125e+00
R_9364_9365 9364 9365 7.918997e+00
R_9365_9366 9365 9366 6.313236e+00
R_9366_9367 9366 9367 8.519339e+00
R_9367_9368 9367 9368 2.793121e+00
R_9368_9369 9368 9369 7.793842e+00
R_9369_9370 9369 9370 4.475262e+00
R_9370_9371 9370 9371 2.806696e-02
R_9371_9372 9371 9372 6.598540e+00
R_9372_9373 9372 9373 5.583575e+00
R_9373_9374 9373 9374 6.919408e+00
R_9374_9375 9374 9375 2.590949e+00
R_9375_9376 9375 9376 1.892404e+00
R_9376_9377 9376 9377 3.925004e+00
R_9377_9378 9377 9378 8.235787e+00
R_9378_9379 9378 9379 8.746100e+00
R_9379_9380 9379 9380 4.804805e+00
R_9380_9381 9380 9381 2.304913e+00
R_9381_9382 9381 9382 2.708769e+00
R_9382_9383 9382 9383 8.290114e-01
R_9383_9384 9383 9384 9.734240e+00
R_9384_9385 9384 9385 3.757822e+00
R_9385_9386 9385 9386 2.168478e+00
R_9386_9387 9386 9387 2.068793e+00
R_9387_9388 9387 9388 8.083629e+00
R_9388_9389 9388 9389 3.984422e+00
R_9389_9390 9389 9390 5.531075e+00
R_9390_9391 9390 9391 8.835994e+00
R_9391_9392 9391 9392 1.698933e+00
R_9392_9393 9392 9393 4.483180e+00
R_9393_9394 9393 9394 5.297556e+00
R_9394_9395 9394 9395 7.077200e+00
R_9395_9396 9395 9396 9.539552e+00
R_9396_9397 9396 9397 8.175383e+00
R_9397_9398 9397 9398 8.382114e+00
R_9398_9399 9398 9399 7.829440e-01
R_9399_9400 9399 9400 2.523588e+00
R_9401_9402 9401 9402 8.345571e+00
R_9402_9403 9402 9403 9.900338e+00
R_9403_9404 9403 9404 7.510486e+00
R_9404_9405 9404 9405 1.630879e+00
R_9405_9406 9405 9406 1.570274e+00
R_9406_9407 9406 9407 7.005082e+00
R_9407_9408 9407 9408 6.597738e+00
R_9408_9409 9408 9409 7.751815e+00
R_9409_9410 9409 9410 6.784052e+00
R_9410_9411 9410 9411 1.975534e+00
R_9411_9412 9411 9412 5.225996e+00
R_9412_9413 9412 9413 6.325455e+00
R_9413_9414 9413 9414 4.296985e+00
R_9414_9415 9414 9415 8.467945e-01
R_9415_9416 9415 9416 8.405712e+00
R_9416_9417 9416 9417 2.466142e+00
R_9417_9418 9417 9418 9.116877e+00
R_9418_9419 9418 9419 1.495517e+00
R_9419_9420 9419 9420 2.950474e+00
R_9420_9421 9420 9421 4.074521e+00
R_9421_9422 9421 9422 1.725872e+00
R_9422_9423 9422 9423 2.270473e+00
R_9423_9424 9423 9424 2.783339e+00
R_9424_9425 9424 9425 8.662785e+00
R_9425_9426 9425 9426 9.777978e+00
R_9426_9427 9426 9427 2.086860e+00
R_9427_9428 9427 9428 1.345927e+00
R_9428_9429 9428 9429 4.545077e+00
R_9429_9430 9429 9430 6.171579e+00
R_9430_9431 9430 9431 6.026694e+00
R_9431_9432 9431 9432 1.241155e+00
R_9432_9433 9432 9433 3.042781e+00
R_9433_9434 9433 9434 9.903984e+00
R_9434_9435 9434 9435 4.948799e+00
R_9435_9436 9435 9436 6.183968e+00
R_9436_9437 9436 9437 1.827582e+00
R_9437_9438 9437 9438 7.835223e+00
R_9438_9439 9438 9439 5.428197e+00
R_9439_9440 9439 9440 1.737548e+00
R_9440_9441 9440 9441 6.904718e+00
R_9441_9442 9441 9442 7.838104e+00
R_9442_9443 9442 9443 7.748177e+00
R_9443_9444 9443 9444 5.758906e+00
R_9444_9445 9444 9445 1.473390e-01
R_9445_9446 9445 9446 5.472056e+00
R_9446_9447 9446 9447 9.705072e+00
R_9447_9448 9447 9448 2.300866e+00
R_9448_9449 9448 9449 5.264408e+00
R_9449_9450 9449 9450 4.939072e+00
R_9450_9451 9450 9451 9.735424e+00
R_9451_9452 9451 9452 7.753816e+00
R_9452_9453 9452 9453 2.388104e+00
R_9453_9454 9453 9454 3.601424e-01
R_9454_9455 9454 9455 9.011129e+00
R_9455_9456 9455 9456 3.338709e-01
R_9456_9457 9456 9457 7.735625e+00
R_9457_9458 9457 9458 9.447446e+00
R_9458_9459 9458 9459 8.689496e+00
R_9459_9460 9459 9460 2.136911e+00
R_9460_9461 9460 9461 8.905380e+00
R_9461_9462 9461 9462 8.560085e+00
R_9462_9463 9462 9463 9.438711e+00
R_9463_9464 9463 9464 6.640052e+00
R_9464_9465 9464 9465 3.481218e+00
R_9465_9466 9465 9466 7.570578e-01
R_9466_9467 9466 9467 9.330309e+00
R_9467_9468 9467 9468 4.487248e+00
R_9468_9469 9468 9469 6.536230e+00
R_9469_9470 9469 9470 8.915455e+00
R_9470_9471 9470 9471 4.382926e+00
R_9471_9472 9471 9472 2.643836e+00
R_9472_9473 9472 9473 6.485681e+00
R_9473_9474 9473 9474 6.239929e+00
R_9474_9475 9474 9475 1.124791e+00
R_9475_9476 9475 9476 2.312696e-01
R_9476_9477 9476 9477 6.653684e-01
R_9477_9478 9477 9478 2.061292e+00
R_9478_9479 9478 9479 1.981395e+00
R_9479_9480 9479 9480 1.950913e+00
R_9480_9481 9480 9481 9.265874e+00
R_9481_9482 9481 9482 5.092079e+00
R_9482_9483 9482 9483 3.477122e+00
R_9483_9484 9483 9484 9.181478e+00
R_9484_9485 9484 9485 4.732396e+00
R_9485_9486 9485 9486 8.155024e+00
R_9486_9487 9486 9487 1.803120e+00
R_9487_9488 9487 9488 2.924136e+00
R_9488_9489 9488 9489 7.253611e+00
R_9489_9490 9489 9490 8.775737e+00
R_9490_9491 9490 9491 2.344623e+00
R_9491_9492 9491 9492 6.491604e+00
R_9492_9493 9492 9493 2.634417e+00
R_9493_9494 9493 9494 9.840113e+00
R_9494_9495 9494 9495 9.261974e+00
R_9495_9496 9495 9496 9.456812e+00
R_9496_9497 9496 9497 4.575280e+00
R_9497_9498 9497 9498 6.604178e+00
R_9498_9499 9498 9499 5.457191e+00
R_9499_9500 9499 9500 5.286382e+00
R_9501_9502 9501 9502 3.907344e+00
R_9502_9503 9502 9503 1.258123e+00
R_9503_9504 9503 9504 3.478956e+00
R_9504_9505 9504 9505 1.082647e+00
R_9505_9506 9505 9506 1.778035e+00
R_9506_9507 9506 9507 4.584830e+00
R_9507_9508 9507 9508 7.648752e+00
R_9508_9509 9508 9509 2.252964e+00
R_9509_9510 9509 9510 4.202505e+00
R_9510_9511 9510 9511 2.424778e+00
R_9511_9512 9511 9512 8.942590e+00
R_9512_9513 9512 9513 9.528911e-02
R_9513_9514 9513 9514 6.553474e+00
R_9514_9515 9514 9515 3.183389e+00
R_9515_9516 9515 9516 4.671968e-01
R_9516_9517 9516 9517 7.723661e+00
R_9517_9518 9517 9518 2.313139e+00
R_9518_9519 9518 9519 9.889354e+00
R_9519_9520 9519 9520 8.410734e-01
R_9520_9521 9520 9521 7.831042e+00
R_9521_9522 9521 9522 8.710593e+00
R_9522_9523 9522 9523 5.405391e+00
R_9523_9524 9523 9524 5.557939e+00
R_9524_9525 9524 9525 3.161084e+00
R_9525_9526 9525 9526 8.271215e+00
R_9526_9527 9526 9527 6.441241e+00
R_9527_9528 9527 9528 2.128193e+00
R_9528_9529 9528 9529 1.608726e+00
R_9529_9530 9529 9530 8.008914e+00
R_9530_9531 9530 9531 1.052987e+00
R_9531_9532 9531 9532 7.756192e-01
R_9532_9533 9532 9533 8.326844e+00
R_9533_9534 9533 9534 6.272126e+00
R_9534_9535 9534 9535 6.470253e+00
R_9535_9536 9535 9536 2.251481e+00
R_9536_9537 9536 9537 6.441509e+00
R_9537_9538 9537 9538 2.953801e-01
R_9538_9539 9538 9539 5.513520e+00
R_9539_9540 9539 9540 1.264918e+00
R_9540_9541 9540 9541 6.458412e+00
R_9541_9542 9541 9542 4.412422e+00
R_9542_9543 9542 9543 3.351940e+00
R_9543_9544 9543 9544 3.082999e+00
R_9544_9545 9544 9545 7.629082e+00
R_9545_9546 9545 9546 9.648908e+00
R_9546_9547 9546 9547 1.798680e+00
R_9547_9548 9547 9548 4.524479e+00
R_9548_9549 9548 9549 8.819790e+00
R_9549_9550 9549 9550 1.433962e+00
R_9550_9551 9550 9551 7.604807e+00
R_9551_9552 9551 9552 3.661099e+00
R_9552_9553 9552 9553 4.137685e+00
R_9553_9554 9553 9554 2.596320e+00
R_9554_9555 9554 9555 4.121206e+00
R_9555_9556 9555 9556 7.218656e+00
R_9556_9557 9556 9557 9.486724e+00
R_9557_9558 9557 9558 2.711754e+00
R_9558_9559 9558 9559 8.317219e+00
R_9559_9560 9559 9560 7.225635e+00
R_9560_9561 9560 9561 3.784348e+00
R_9561_9562 9561 9562 4.506085e+00
R_9562_9563 9562 9563 5.953954e-01
R_9563_9564 9563 9564 9.823235e+00
R_9564_9565 9564 9565 6.548076e+00
R_9565_9566 9565 9566 1.649842e-01
R_9566_9567 9566 9567 3.680863e+00
R_9567_9568 9567 9568 6.246819e+00
R_9568_9569 9568 9569 8.061230e+00
R_9569_9570 9569 9570 2.864760e-01
R_9570_9571 9570 9571 2.072548e+00
R_9571_9572 9571 9572 1.167403e+00
R_9572_9573 9572 9573 3.442920e+00
R_9573_9574 9573 9574 3.564663e+00
R_9574_9575 9574 9575 6.864908e+00
R_9575_9576 9575 9576 3.900145e+00
R_9576_9577 9576 9577 9.302833e+00
R_9577_9578 9577 9578 6.483923e+00
R_9578_9579 9578 9579 3.148314e+00
R_9579_9580 9579 9580 5.794012e+00
R_9580_9581 9580 9581 8.236144e+00
R_9581_9582 9581 9582 7.072370e+00
R_9582_9583 9582 9583 1.506757e+00
R_9583_9584 9583 9584 9.220883e+00
R_9584_9585 9584 9585 1.323273e+00
R_9585_9586 9585 9586 1.908865e+00
R_9586_9587 9586 9587 7.023721e+00
R_9587_9588 9587 9588 8.341874e+00
R_9588_9589 9588 9589 2.553495e+00
R_9589_9590 9589 9590 8.153062e+00
R_9590_9591 9590 9591 7.927630e+00
R_9591_9592 9591 9592 6.558887e+00
R_9592_9593 9592 9593 7.560852e+00
R_9593_9594 9593 9594 3.630329e+00
R_9594_9595 9594 9595 7.435643e+00
R_9595_9596 9595 9596 5.521498e+00
R_9596_9597 9596 9597 2.930188e+00
R_9597_9598 9597 9598 2.768399e+00
R_9598_9599 9598 9599 5.992808e+00
R_9599_9600 9599 9600 7.224183e+00
R_9601_9602 9601 9602 4.804307e+00
R_9602_9603 9602 9603 7.419338e+00
R_9603_9604 9603 9604 6.079920e-02
R_9604_9605 9604 9605 6.188335e+00
R_9605_9606 9605 9606 5.078901e+00
R_9606_9607 9606 9607 9.634434e+00
R_9607_9608 9607 9608 3.929279e+00
R_9608_9609 9608 9609 3.501512e+00
R_9609_9610 9609 9610 9.009236e+00
R_9610_9611 9610 9611 8.624363e+00
R_9611_9612 9611 9612 5.809626e+00
R_9612_9613 9612 9613 4.401681e+00
R_9613_9614 9613 9614 3.887016e+00
R_9614_9615 9614 9615 6.169959e+00
R_9615_9616 9615 9616 9.743828e+00
R_9616_9617 9616 9617 3.088008e+00
R_9617_9618 9617 9618 5.964295e+00
R_9618_9619 9618 9619 2.947769e+00
R_9619_9620 9619 9620 8.177555e+00
R_9620_9621 9620 9621 8.797448e+00
R_9621_9622 9621 9622 2.546757e+00
R_9622_9623 9622 9623 3.957266e+00
R_9623_9624 9623 9624 8.431866e+00
R_9624_9625 9624 9625 2.047353e+00
R_9625_9626 9625 9626 6.697483e+00
R_9626_9627 9626 9627 3.177074e+00
R_9627_9628 9627 9628 5.280788e+00
R_9628_9629 9628 9629 2.546834e+00
R_9629_9630 9629 9630 7.603992e+00
R_9630_9631 9630 9631 4.903485e+00
R_9631_9632 9631 9632 3.618522e+00
R_9632_9633 9632 9633 2.152781e-01
R_9633_9634 9633 9634 1.533156e+00
R_9634_9635 9634 9635 9.082624e+00
R_9635_9636 9635 9636 5.832162e+00
R_9636_9637 9636 9637 9.241730e+00
R_9637_9638 9637 9638 2.197545e+00
R_9638_9639 9638 9639 4.410151e+00
R_9639_9640 9639 9640 5.228605e+00
R_9640_9641 9640 9641 6.486742e+00
R_9641_9642 9641 9642 9.729367e+00
R_9642_9643 9642 9643 4.460645e+00
R_9643_9644 9643 9644 4.114689e+00
R_9644_9645 9644 9645 3.645256e+00
R_9645_9646 9645 9646 1.485123e+00
R_9646_9647 9646 9647 3.189138e+00
R_9647_9648 9647 9648 4.219811e+00
R_9648_9649 9648 9649 6.471082e+00
R_9649_9650 9649 9650 4.369010e+00
R_9650_9651 9650 9651 4.150248e+00
R_9651_9652 9651 9652 8.112197e+00
R_9652_9653 9652 9653 5.791117e-01
R_9653_9654 9653 9654 6.515228e-01
R_9654_9655 9654 9655 6.290985e+00
R_9655_9656 9655 9656 8.488170e+00
R_9656_9657 9656 9657 6.518826e+00
R_9657_9658 9657 9658 2.277530e+00
R_9658_9659 9658 9659 3.758985e+00
R_9659_9660 9659 9660 9.942968e+00
R_9660_9661 9660 9661 1.408244e-02
R_9661_9662 9661 9662 9.798828e-01
R_9662_9663 9662 9663 4.844300e+00
R_9663_9664 9663 9664 7.841685e+00
R_9664_9665 9664 9665 4.614474e+00
R_9665_9666 9665 9666 5.917700e+00
R_9666_9667 9666 9667 6.398525e+00
R_9667_9668 9667 9668 6.576381e-01
R_9668_9669 9668 9669 7.018392e+00
R_9669_9670 9669 9670 6.488710e+00
R_9670_9671 9670 9671 4.127692e+00
R_9671_9672 9671 9672 3.471129e-01
R_9672_9673 9672 9673 6.026223e+00
R_9673_9674 9673 9674 4.718542e+00
R_9674_9675 9674 9675 7.285683e+00
R_9675_9676 9675 9676 5.115718e+00
R_9676_9677 9676 9677 2.131440e+00
R_9677_9678 9677 9678 1.434454e+00
R_9678_9679 9678 9679 7.871862e+00
R_9679_9680 9679 9680 6.754133e-01
R_9680_9681 9680 9681 6.384725e+00
R_9681_9682 9681 9682 3.474702e+00
R_9682_9683 9682 9683 2.860637e+00
R_9683_9684 9683 9684 8.845240e+00
R_9684_9685 9684 9685 9.509156e+00
R_9685_9686 9685 9686 1.166471e+00
R_9686_9687 9686 9687 4.772143e+00
R_9687_9688 9687 9688 5.635242e+00
R_9688_9689 9688 9689 4.573244e+00
R_9689_9690 9689 9690 5.598552e+00
R_9690_9691 9690 9691 8.322841e+00
R_9691_9692 9691 9692 6.256777e+00
R_9692_9693 9692 9693 7.952031e+00
R_9693_9694 9693 9694 1.181890e+00
R_9694_9695 9694 9695 9.011215e-01
R_9695_9696 9695 9696 8.261864e-01
R_9696_9697 9696 9697 1.984711e+00
R_9697_9698 9697 9698 6.853788e+00
R_9698_9699 9698 9699 9.358524e+00
R_9699_9700 9699 9700 6.104713e-01
R_9701_9702 9701 9702 1.034554e+00
R_9702_9703 9702 9703 2.360628e+00
R_9703_9704 9703 9704 2.677255e+00
R_9704_9705 9704 9705 9.620267e+00
R_9705_9706 9705 9706 9.460597e+00
R_9706_9707 9706 9707 5.119837e-01
R_9707_9708 9707 9708 1.343822e+00
R_9708_9709 9708 9709 3.500364e+00
R_9709_9710 9709 9710 7.124683e+00
R_9710_9711 9710 9711 7.504501e+00
R_9711_9712 9711 9712 6.685307e-02
R_9712_9713 9712 9713 9.189023e+00
R_9713_9714 9713 9714 5.255716e+00
R_9714_9715 9714 9715 5.804657e+00
R_9715_9716 9715 9716 1.353142e-01
R_9716_9717 9716 9717 4.028373e+00
R_9717_9718 9717 9718 9.774964e+00
R_9718_9719 9718 9719 4.044016e+00
R_9719_9720 9719 9720 9.285383e+00
R_9720_9721 9720 9721 3.001415e+00
R_9721_9722 9721 9722 6.261739e+00
R_9722_9723 9722 9723 9.230562e+00
R_9723_9724 9723 9724 3.663702e+00
R_9724_9725 9724 9725 4.527177e-01
R_9725_9726 9725 9726 3.066371e+00
R_9726_9727 9726 9727 8.536879e+00
R_9727_9728 9727 9728 5.944812e-01
R_9728_9729 9728 9729 8.779428e+00
R_9729_9730 9729 9730 5.054841e+00
R_9730_9731 9730 9731 6.120472e+00
R_9731_9732 9731 9732 6.859903e+00
R_9732_9733 9732 9733 4.063362e-02
R_9733_9734 9733 9734 4.659399e+00
R_9734_9735 9734 9735 6.574415e+00
R_9735_9736 9735 9736 3.731354e+00
R_9736_9737 9736 9737 1.491342e+00
R_9737_9738 9737 9738 4.576013e+00
R_9738_9739 9738 9739 6.307608e+00
R_9739_9740 9739 9740 5.692207e+00
R_9740_9741 9740 9741 4.646526e+00
R_9741_9742 9741 9742 6.296753e+00
R_9742_9743 9742 9743 8.127368e+00
R_9743_9744 9743 9744 3.491807e+00
R_9744_9745 9744 9745 8.846542e+00
R_9745_9746 9745 9746 9.036332e+00
R_9746_9747 9746 9747 5.432201e+00
R_9747_9748 9747 9748 6.087970e+00
R_9748_9749 9748 9749 6.663182e+00
R_9749_9750 9749 9750 4.924958e+00
R_9750_9751 9750 9751 7.520342e-02
R_9751_9752 9751 9752 4.782485e+00
R_9752_9753 9752 9753 5.057549e+00
R_9753_9754 9753 9754 9.909106e+00
R_9754_9755 9754 9755 8.186490e+00
R_9755_9756 9755 9756 2.444988e+00
R_9756_9757 9756 9757 5.782545e+00
R_9757_9758 9757 9758 7.020434e+00
R_9758_9759 9758 9759 5.772838e+00
R_9759_9760 9759 9760 3.607179e+00
R_9760_9761 9760 9761 2.611869e+00
R_9761_9762 9761 9762 4.970617e+00
R_9762_9763 9762 9763 9.609739e+00
R_9763_9764 9763 9764 8.636439e-01
R_9764_9765 9764 9765 8.141484e+00
R_9765_9766 9765 9766 1.967605e+00
R_9766_9767 9766 9767 1.187563e-01
R_9767_9768 9767 9768 4.546940e-01
R_9768_9769 9768 9769 2.882922e+00
R_9769_9770 9769 9770 8.813196e-01
R_9770_9771 9770 9771 8.750076e+00
R_9771_9772 9771 9772 7.272335e+00
R_9772_9773 9772 9773 5.954523e+00
R_9773_9774 9773 9774 2.918630e+00
R_9774_9775 9774 9775 8.194830e+00
R_9775_9776 9775 9776 2.978503e+00
R_9776_9777 9776 9777 8.546334e+00
R_9777_9778 9777 9778 8.995505e+00
R_9778_9779 9778 9779 5.867275e+00
R_9779_9780 9779 9780 2.842353e+00
R_9780_9781 9780 9781 3.993803e-01
R_9781_9782 9781 9782 5.910356e-01
R_9782_9783 9782 9783 9.589866e+00
R_9783_9784 9783 9784 6.633965e+00
R_9784_9785 9784 9785 3.295920e-01
R_9785_9786 9785 9786 8.492161e-03
R_9786_9787 9786 9787 6.732074e+00
R_9787_9788 9787 9788 7.644230e+00
R_9788_9789 9788 9789 5.796503e+00
R_9789_9790 9789 9790 3.751697e+00
R_9790_9791 9790 9791 7.063923e+00
R_9791_9792 9791 9792 2.096822e+00
R_9792_9793 9792 9793 8.796976e+00
R_9793_9794 9793 9794 3.522945e+00
R_9794_9795 9794 9795 8.638038e+00
R_9795_9796 9795 9796 4.115968e-01
R_9796_9797 9796 9797 9.044180e+00
R_9797_9798 9797 9798 3.065980e+00
R_9798_9799 9798 9799 1.983703e+00
R_9799_9800 9799 9800 4.867676e+00
R_9801_9802 9801 9802 2.321231e+00
R_9802_9803 9802 9803 3.017951e+00
R_9803_9804 9803 9804 4.730081e+00
R_9804_9805 9804 9805 7.632690e+00
R_9805_9806 9805 9806 6.227693e+00
R_9806_9807 9806 9807 2.891078e+00
R_9807_9808 9807 9808 9.432070e+00
R_9808_9809 9808 9809 7.465731e+00
R_9809_9810 9809 9810 3.214190e+00
R_9810_9811 9810 9811 9.180978e+00
R_9811_9812 9811 9812 5.264185e-01
R_9812_9813 9812 9813 6.088830e+00
R_9813_9814 9813 9814 6.947604e-02
R_9814_9815 9814 9815 7.192745e-01
R_9815_9816 9815 9816 6.030537e+00
R_9816_9817 9816 9817 2.351340e+00
R_9817_9818 9817 9818 6.523080e+00
R_9818_9819 9818 9819 5.109085e+00
R_9819_9820 9819 9820 2.179664e+00
R_9820_9821 9820 9821 3.782436e+00
R_9821_9822 9821 9822 2.559956e+00
R_9822_9823 9822 9823 7.147838e-01
R_9823_9824 9823 9824 7.337433e+00
R_9824_9825 9824 9825 1.981822e+00
R_9825_9826 9825 9826 7.949754e+00
R_9826_9827 9826 9827 7.829726e+00
R_9827_9828 9827 9828 1.156294e+00
R_9828_9829 9828 9829 7.148315e+00
R_9829_9830 9829 9830 2.540528e+00
R_9830_9831 9830 9831 2.927352e+00
R_9831_9832 9831 9832 1.063577e+00
R_9832_9833 9832 9833 5.491422e+00
R_9833_9834 9833 9834 3.862266e+00
R_9834_9835 9834 9835 9.130145e+00
R_9835_9836 9835 9836 4.898427e+00
R_9836_9837 9836 9837 2.724154e+00
R_9837_9838 9837 9838 4.536555e+00
R_9838_9839 9838 9839 2.093415e-01
R_9839_9840 9839 9840 8.209456e+00
R_9840_9841 9840 9841 6.317877e+00
R_9841_9842 9841 9842 9.997973e+00
R_9842_9843 9842 9843 3.059030e-01
R_9843_9844 9843 9844 1.696964e+00
R_9844_9845 9844 9845 8.915793e+00
R_9845_9846 9845 9846 4.730618e-01
R_9846_9847 9846 9847 6.804313e+00
R_9847_9848 9847 9848 4.421677e-01
R_9848_9849 9848 9849 6.006092e+00
R_9849_9850 9849 9850 1.995487e+00
R_9850_9851 9850 9851 3.589920e+00
R_9851_9852 9851 9852 4.324272e+00
R_9852_9853 9852 9853 9.672511e+00
R_9853_9854 9853 9854 7.187127e+00
R_9854_9855 9854 9855 5.738372e-01
R_9855_9856 9855 9856 6.357570e+00
R_9856_9857 9856 9857 2.032083e+00
R_9857_9858 9857 9858 2.546135e+00
R_9858_9859 9858 9859 1.778542e+00
R_9859_9860 9859 9860 3.928961e+00
R_9860_9861 9860 9861 4.078396e+00
R_9861_9862 9861 9862 5.712202e+00
R_9862_9863 9862 9863 8.972802e+00
R_9863_9864 9863 9864 5.433823e+00
R_9864_9865 9864 9865 8.604528e+00
R_9865_9866 9865 9866 2.042042e+00
R_9866_9867 9866 9867 9.948377e+00
R_9867_9868 9867 9868 7.485410e+00
R_9868_9869 9868 9869 7.989782e+00
R_9869_9870 9869 9870 8.330004e+00
R_9870_9871 9870 9871 7.408447e+00
R_9871_9872 9871 9872 2.322961e+00
R_9872_9873 9872 9873 8.933264e+00
R_9873_9874 9873 9874 8.164299e+00
R_9874_9875 9874 9875 3.084148e+00
R_9875_9876 9875 9876 1.963001e+00
R_9876_9877 9876 9877 9.192781e+00
R_9877_9878 9877 9878 2.405630e+00
R_9878_9879 9878 9879 6.108837e+00
R_9879_9880 9879 9880 1.358407e+00
R_9880_9881 9880 9881 4.826702e+00
R_9881_9882 9881 9882 4.326427e+00
R_9882_9883 9882 9883 2.595072e-02
R_9883_9884 9883 9884 2.440977e+00
R_9884_9885 9884 9885 5.891221e+00
R_9885_9886 9885 9886 8.838981e+00
R_9886_9887 9886 9887 7.770004e+00
R_9887_9888 9887 9888 5.331774e+00
R_9888_9889 9888 9889 3.987559e-01
R_9889_9890 9889 9890 7.173257e+00
R_9890_9891 9890 9891 1.171492e+00
R_9891_9892 9891 9892 3.343513e+00
R_9892_9893 9892 9893 7.510910e+00
R_9893_9894 9893 9894 7.641521e+00
R_9894_9895 9894 9895 5.108788e+00
R_9895_9896 9895 9896 7.504758e+00
R_9896_9897 9896 9897 4.345526e+00
R_9897_9898 9897 9898 1.820031e+00
R_9898_9899 9898 9899 9.069062e+00
R_9899_9900 9899 9900 2.243990e+00
R_9901_9902 9901 9902 4.660194e+00
R_9902_9903 9902 9903 8.138567e+00
R_9903_9904 9903 9904 3.748642e+00
R_9904_9905 9904 9905 4.653652e+00
R_9905_9906 9905 9906 5.656248e-01
R_9906_9907 9906 9907 3.582161e+00
R_9907_9908 9907 9908 6.606476e+00
R_9908_9909 9908 9909 4.562084e-01
R_9909_9910 9909 9910 2.318417e+00
R_9910_9911 9910 9911 1.682374e-01
R_9911_9912 9911 9912 7.736193e+00
R_9912_9913 9912 9913 9.491242e+00
R_9913_9914 9913 9914 4.337035e+00
R_9914_9915 9914 9915 1.937939e+00
R_9915_9916 9915 9916 6.119840e-01
R_9916_9917 9916 9917 2.546540e+00
R_9917_9918 9917 9918 8.994091e+00
R_9918_9919 9918 9919 4.920854e+00
R_9919_9920 9919 9920 1.685687e+00
R_9920_9921 9920 9921 4.039209e-01
R_9921_9922 9921 9922 1.112850e+00
R_9922_9923 9922 9923 6.048398e+00
R_9923_9924 9923 9924 8.438895e+00
R_9924_9925 9924 9925 2.776121e+00
R_9925_9926 9925 9926 5.606539e+00
R_9926_9927 9926 9927 6.194741e+00
R_9927_9928 9927 9928 8.465279e+00
R_9928_9929 9928 9929 6.078161e+00
R_9929_9930 9929 9930 1.993161e+00
R_9930_9931 9930 9931 9.534172e+00
R_9931_9932 9931 9932 9.331829e+00
R_9932_9933 9932 9933 4.770543e+00
R_9933_9934 9933 9934 1.713510e+00
R_9934_9935 9934 9935 1.376355e+00
R_9935_9936 9935 9936 6.757228e+00
R_9936_9937 9936 9937 1.405408e+00
R_9937_9938 9937 9938 2.457766e+00
R_9938_9939 9938 9939 5.009289e+00
R_9939_9940 9939 9940 4.054995e-01
R_9940_9941 9940 9941 1.112534e+00
R_9941_9942 9941 9942 9.020557e+00
R_9942_9943 9942 9943 3.731543e+00
R_9943_9944 9943 9944 2.974099e+00
R_9944_9945 9944 9945 6.574349e+00
R_9945_9946 9945 9946 4.748630e+00
R_9946_9947 9946 9947 5.231200e+00
R_9947_9948 9947 9948 8.344787e-02
R_9948_9949 9948 9949 9.146377e+00
R_9949_9950 9949 9950 2.833060e+00
R_9950_9951 9950 9951 9.407146e+00
R_9951_9952 9951 9952 5.650460e+00
R_9952_9953 9952 9953 9.654169e+00
R_9953_9954 9953 9954 4.962314e+00
R_9954_9955 9954 9955 1.118830e+00
R_9955_9956 9955 9956 6.933861e+00
R_9956_9957 9956 9957 6.880968e+00
R_9957_9958 9957 9958 9.525033e+00
R_9958_9959 9958 9959 2.077912e-01
R_9959_9960 9959 9960 4.726224e+00
R_9960_9961 9960 9961 8.339991e+00
R_9961_9962 9961 9962 7.116308e+00
R_9962_9963 9962 9963 4.532897e+00
R_9963_9964 9963 9964 5.031230e+00
R_9964_9965 9964 9965 2.081337e+00
R_9965_9966 9965 9966 4.780977e+00
R_9966_9967 9966 9967 8.692404e+00
R_9967_9968 9967 9968 1.079218e+00
R_9968_9969 9968 9969 3.206583e+00
R_9969_9970 9969 9970 9.980647e+00
R_9970_9971 9970 9971 3.106081e+00
R_9971_9972 9971 9972 9.116798e+00
R_9972_9973 9972 9973 5.274769e+00
R_9973_9974 9973 9974 2.524186e+00
R_9974_9975 9974 9975 3.692985e+00
R_9975_9976 9975 9976 5.142254e+00
R_9976_9977 9976 9977 4.055327e+00
R_9977_9978 9977 9978 3.064838e+00
R_9978_9979 9978 9979 4.326067e+00
R_9979_9980 9979 9980 2.555503e+00
R_9980_9981 9980 9981 5.899758e+00
R_9981_9982 9981 9982 3.688213e+00
R_9982_9983 9982 9983 4.187744e+00
R_9983_9984 9983 9984 9.623524e+00
R_9984_9985 9984 9985 8.172429e+00
R_9985_9986 9985 9986 2.347219e+00
R_9986_9987 9986 9987 7.116137e-02
R_9987_9988 9987 9988 4.886848e+00
R_9988_9989 9988 9989 5.370970e+00
R_9989_9990 9989 9990 1.205706e-01
R_9990_9991 9990 9991 1.170065e-02
R_9991_9992 9991 9992 4.332025e+00
R_9992_9993 9992 9993 2.935533e+00
R_9993_9994 9993 9994 8.951717e+00
R_9994_9995 9994 9995 6.904075e-01
R_9995_9996 9995 9996 8.054409e+00
R_9996_9997 9996 9997 1.277750e+00
R_9997_9998 9997 9998 4.475768e+00
R_9998_9999 9998 9999 4.432993e+00
R_9999_10000 9999 10000 6.896135e+00
R_1_101 1 101 3.307575e+00
R_101_201 101 201 2.015017e+00
R_201_301 201 301 5.106379e+00
R_301_401 301 401 3.799937e+00
R_401_501 401 501 4.103273e+00
R_501_601 501 601 1.886791e+00
R_601_701 601 701 7.687788e+00
R_701_801 701 801 3.187278e+00
R_801_901 801 901 4.358498e+00
R_901_1001 901 1001 1.637487e+00
R_1001_1101 1001 1101 3.871833e+00
R_1101_1201 1101 1201 3.450601e+00
R_1201_1301 1201 1301 1.773361e+00
R_1301_1401 1301 1401 5.611377e+00
R_1401_1501 1401 1501 4.526730e+00
R_1501_1601 1501 1601 7.581870e+00
R_1601_1701 1601 1701 2.959247e+00
R_1701_1801 1701 1801 7.614933e+00
R_1801_1901 1801 1901 1.554655e+00
R_1901_2001 1901 2001 7.448839e+00
R_2001_2101 2001 2101 1.342655e+00
R_2101_2201 2101 2201 4.518637e+00
R_2201_2301 2201 2301 7.771647e+00
R_2301_2401 2301 2401 9.450596e+00
R_2401_2501 2401 2501 3.751434e+00
R_2501_2601 2501 2601 9.798228e+00
R_2601_2701 2601 2701 6.103453e+00
R_2701_2801 2701 2801 6.185925e+00
R_2801_2901 2801 2901 4.049516e+00
R_2901_3001 2901 3001 6.867635e+00
R_3001_3101 3001 3101 5.488073e+00
R_3101_3201 3101 3201 6.117262e+00
R_3201_3301 3201 3301 3.822233e+00
R_3301_3401 3301 3401 9.286185e-02
R_3401_3501 3401 3501 1.171657e+00
R_3501_3601 3501 3601 2.048276e+00
R_3601_3701 3601 3701 9.193599e+00
R_3701_3801 3701 3801 4.121231e+00
R_3801_3901 3801 3901 2.997462e+00
R_3901_4001 3901 4001 3.476023e+00
R_4001_4101 4001 4101 4.495971e+00
R_4101_4201 4101 4201 8.452379e+00
R_4201_4301 4201 4301 8.249438e+00
R_4301_4401 4301 4401 3.869778e+00
R_4401_4501 4401 4501 7.791537e+00
R_4501_4601 4501 4601 3.745793e-01
R_4601_4701 4601 4701 8.038998e+00
R_4701_4801 4701 4801 3.636158e+00
R_4801_4901 4801 4901 1.125706e+00
R_4901_5001 4901 5001 7.800583e+00
R_5001_5101 5001 5101 5.353877e+00
R_5101_5201 5101 5201 2.854928e+00
R_5201_5301 5201 5301 7.737645e+00
R_5301_5401 5301 5401 5.118848e+00
R_5401_5501 5401 5501 7.092841e+00
R_5501_5601 5501 5601 2.127725e+00
R_5601_5701 5601 5701 5.595137e+00
R_5701_5801 5701 5801 9.924610e+00
R_5801_5901 5801 5901 3.283236e+00
R_5901_6001 5901 6001 4.891906e+00
R_6001_6101 6001 6101 7.580115e+00
R_6101_6201 6101 6201 6.325403e+00
R_6201_6301 6201 6301 7.364963e+00
R_6301_6401 6301 6401 4.826326e+00
R_6401_6501 6401 6501 7.027731e+00
R_6501_6601 6501 6601 9.611210e+00
R_6601_6701 6601 6701 5.725635e+00
R_6701_6801 6701 6801 5.814998e+00
R_6801_6901 6801 6901 7.661237e+00
R_6901_7001 6901 7001 2.100026e+00
R_7001_7101 7001 7101 4.318216e+00
R_7101_7201 7101 7201 1.369180e+00
R_7201_7301 7201 7301 7.767058e+00
R_7301_7401 7301 7401 8.684389e+00
R_7401_7501 7401 7501 2.451342e+00
R_7501_7601 7501 7601 4.233846e+00
R_7601_7701 7601 7701 5.028594e+00
R_7701_7801 7701 7801 6.914575e+00
R_7801_7901 7801 7901 5.467735e+00
R_7901_8001 7901 8001 7.478596e+00
R_8001_8101 8001 8101 7.385581e+00
R_8101_8201 8101 8201 7.518851e+00
R_8201_8301 8201 8301 4.782475e+00
R_8301_8401 8301 8401 3.316769e+00
R_8401_8501 8401 8501 5.821231e+00
R_8501_8601 8501 8601 1.607123e+00
R_8601_8701 8601 8701 5.048329e+00
R_8701_8801 8701 8801 4.745294e+00
R_8801_8901 8801 8901 7.474307e+00
R_8901_9001 8901 9001 3.240902e+00
R_9001_9101 9001 9101 6.259972e+00
R_9101_9201 9101 9201 4.059438e-01
R_9201_9301 9201 9301 4.879221e+00
R_9301_9401 9301 9401 9.434593e+00
R_9401_9501 9401 9501 4.562809e+00
R_9501_9601 9501 9601 3.006240e+00
R_9601_9701 9601 9701 3.379682e+00
R_9701_9801 9701 9801 6.746566e+00
R_9801_9901 9801 9901 2.987056e+00
R_2_102 2 102 8.375754e+00
R_102_202 102 202 3.351872e+00
R_202_302 202 302 6.049713e+00
R_302_402 302 402 5.112607e+00
R_402_502 402 502 5.924664e+00
R_502_602 502 602 1.757481e+00
R_602_702 602 702 9.228518e+00
R_702_802 702 802 2.219710e+00
R_802_902 802 902 9.161935e+00
R_902_1002 902 1002 4.892300e-01
R_1002_1102 1002 1102 8.754159e+00
R_1102_1202 1102 1202 4.124666e+00
R_1202_1302 1202 1302 2.345323e+00
R_1302_1402 1302 1402 9.586510e+00
R_1402_1502 1402 1502 5.895847e+00
R_1502_1602 1502 1602 1.774505e+00
R_1602_1702 1602 1702 9.370101e+00
R_1702_1802 1702 1802 5.339463e-01
R_1802_1902 1802 1902 7.713588e+00
R_1902_2002 1902 2002 2.848903e+00
R_2002_2102 2002 2102 7.239680e+00
R_2102_2202 2102 2202 2.494949e+00
R_2202_2302 2202 2302 7.056691e+00
R_2302_2402 2302 2402 2.300301e+00
R_2402_2502 2402 2502 1.539431e+00
R_2502_2602 2502 2602 3.255424e+00
R_2602_2702 2602 2702 4.078235e+00
R_2702_2802 2702 2802 4.777631e+00
R_2802_2902 2802 2902 3.503993e+00
R_2902_3002 2902 3002 2.088700e+00
R_3002_3102 3002 3102 6.713101e+00
R_3102_3202 3102 3202 4.970232e+00
R_3202_3302 3202 3302 9.275441e+00
R_3302_3402 3302 3402 1.177716e+00
R_3402_3502 3402 3502 6.208426e-01
R_3502_3602 3502 3602 4.150949e+00
R_3602_3702 3602 3702 6.708212e-01
R_3702_3802 3702 3802 1.186994e+00
R_3802_3902 3802 3902 5.643760e+00
R_3902_4002 3902 4002 9.816647e+00
R_4002_4102 4002 4102 5.302711e+00
R_4102_4202 4102 4202 6.789691e+00
R_4202_4302 4202 4302 6.948049e+00
R_4302_4402 4302 4402 2.940911e+00
R_4402_4502 4402 4502 8.503279e+00
R_4502_4602 4502 4602 4.734431e-01
R_4602_4702 4602 4702 5.633012e+00
R_4702_4802 4702 4802 7.311506e+00
R_4802_4902 4802 4902 9.636026e+00
R_4902_5002 4902 5002 8.558724e+00
R_5002_5102 5002 5102 8.054924e+00
R_5102_5202 5102 5202 3.737362e+00
R_5202_5302 5202 5302 5.353267e+00
R_5302_5402 5302 5402 7.798306e-01
R_5402_5502 5402 5502 7.104432e+00
R_5502_5602 5502 5602 2.127988e+00
R_5602_5702 5602 5702 7.392689e+00
R_5702_5802 5702 5802 2.028307e+00
R_5802_5902 5802 5902 6.452694e+00
R_5902_6002 5902 6002 7.608631e-01
R_6002_6102 6002 6102 9.279202e+00
R_6102_6202 6102 6202 2.470777e-01
R_6202_6302 6202 6302 1.470387e+00
R_6302_6402 6302 6402 6.584277e+00
R_6402_6502 6402 6502 8.984950e+00
R_6502_6602 6502 6602 2.276248e+00
R_6602_6702 6602 6702 2.153087e+00
R_6702_6802 6702 6802 8.388861e+00
R_6802_6902 6802 6902 3.841664e+00
R_6902_7002 6902 7002 4.279776e+00
R_7002_7102 7002 7102 2.577909e+00
R_7102_7202 7102 7202 3.167523e+00
R_7202_7302 7202 7302 1.980307e+00
R_7302_7402 7302 7402 3.659405e+00
R_7402_7502 7402 7502 6.079957e+00
R_7502_7602 7502 7602 9.819824e+00
R_7602_7702 7602 7702 1.500678e+00
R_7702_7802 7702 7802 4.433748e+00
R_7802_7902 7802 7902 2.626755e+00
R_7902_8002 7902 8002 6.266718e+00
R_8002_8102 8002 8102 6.345157e-01
R_8102_8202 8102 8202 2.931341e+00
R_8202_8302 8202 8302 9.020741e+00
R_8302_8402 8302 8402 9.106957e+00
R_8402_8502 8402 8502 7.060516e+00
R_8502_8602 8502 8602 9.589573e+00
R_8602_8702 8602 8702 1.346462e-01
R_8702_8802 8702 8802 1.913131e+00
R_8802_8902 8802 8902 8.716602e+00
R_8902_9002 8902 9002 2.712867e+00
R_9002_9102 9002 9102 2.681958e+00
R_9102_9202 9102 9202 8.972120e-01
R_9202_9302 9202 9302 4.480255e+00
R_9302_9402 9302 9402 3.147295e+00
R_9402_9502 9402 9502 1.458263e+00
R_9502_9602 9502 9602 1.730132e+00
R_9602_9702 9602 9702 4.845008e+00
R_9702_9802 9702 9802 5.957598e+00
R_9802_9902 9802 9902 5.922931e+00
R_3_103 3 103 1.160190e-01
R_103_203 103 203 7.289404e-01
R_203_303 203 303 2.680636e+00
R_303_403 303 403 5.600134e+00
R_403_503 403 503 5.307419e+00
R_503_603 503 603 8.824888e+00
R_603_703 603 703 7.408112e+00
R_703_803 703 803 5.012172e+00
R_803_903 803 903 9.759690e-01
R_903_1003 903 1003 7.511809e+00
R_1003_1103 1003 1103 5.753931e+00
R_1103_1203 1103 1203 2.252953e+00
R_1203_1303 1203 1303 1.233353e+00
R_1303_1403 1303 1403 8.942040e+00
R_1403_1503 1403 1503 3.207527e+00
R_1503_1603 1503 1603 2.790433e+00
R_1603_1703 1603 1703 4.794233e+00
R_1703_1803 1703 1803 1.834701e+00
R_1803_1903 1803 1903 7.936499e+00
R_1903_2003 1903 2003 6.624781e+00
R_2003_2103 2003 2103 4.877062e+00
R_2103_2203 2103 2203 3.920430e+00
R_2203_2303 2203 2303 4.867917e+00
R_2303_2403 2303 2403 6.236467e+00
R_2403_2503 2403 2503 2.588975e-01
R_2503_2603 2503 2603 6.472457e+00
R_2603_2703 2603 2703 8.163441e+00
R_2703_2803 2703 2803 8.531790e+00
R_2803_2903 2803 2903 4.272637e+00
R_2903_3003 2903 3003 5.237160e+00
R_3003_3103 3003 3103 8.562311e+00
R_3103_3203 3103 3203 9.372004e-01
R_3203_3303 3203 3303 5.564133e+00
R_3303_3403 3303 3403 5.615285e+00
R_3403_3503 3403 3503 8.802673e+00
R_3503_3603 3503 3603 6.957715e+00
R_3603_3703 3603 3703 5.092654e+00
R_3703_3803 3703 3803 6.029414e-01
R_3803_3903 3803 3903 6.370041e+00
R_3903_4003 3903 4003 2.724140e-01
R_4003_4103 4003 4103 7.747513e+00
R_4103_4203 4103 4203 4.503459e+00
R_4203_4303 4203 4303 6.911984e+00
R_4303_4403 4303 4403 4.007741e+00
R_4403_4503 4403 4503 1.331294e+00
R_4503_4603 4503 4603 9.672192e+00
R_4603_4703 4603 4703 8.054080e+00
R_4703_4803 4703 4803 5.766827e+00
R_4803_4903 4803 4903 6.882481e+00
R_4903_5003 4903 5003 6.045689e+00
R_5003_5103 5003 5103 4.675884e+00
R_5103_5203 5103 5203 8.363423e+00
R_5203_5303 5203 5303 9.288069e+00
R_5303_5403 5303 5403 6.026303e+00
R_5403_5503 5403 5503 3.739663e+00
R_5503_5603 5503 5603 2.086669e+00
R_5603_5703 5603 5703 8.908260e+00
R_5703_5803 5703 5803 8.749873e+00
R_5803_5903 5803 5903 8.356399e+00
R_5903_6003 5903 6003 9.949268e-01
R_6003_6103 6003 6103 6.314387e+00
R_6103_6203 6103 6203 6.166442e+00
R_6203_6303 6203 6303 3.575880e+00
R_6303_6403 6303 6403 8.495028e+00
R_6403_6503 6403 6503 2.402558e+00
R_6503_6603 6503 6603 5.657863e+00
R_6603_6703 6603 6703 1.539141e+00
R_6703_6803 6703 6803 2.769842e+00
R_6803_6903 6803 6903 1.801772e+00
R_6903_7003 6903 7003 7.007435e+00
R_7003_7103 7003 7103 3.833676e+00
R_7103_7203 7103 7203 6.722878e-01
R_7203_7303 7203 7303 5.756208e+00
R_7303_7403 7303 7403 2.865493e+00
R_7403_7503 7403 7503 4.469956e+00
R_7503_7603 7503 7603 7.697005e+00
R_7603_7703 7603 7703 1.656507e+00
R_7703_7803 7703 7803 7.699153e+00
R_7803_7903 7803 7903 3.213999e+00
R_7903_8003 7903 8003 7.960878e+00
R_8003_8103 8003 8103 3.414201e+00
R_8103_8203 8103 8203 7.466433e+00
R_8203_8303 8203 8303 3.328541e+00
R_8303_8403 8303 8403 5.002291e-01
R_8403_8503 8403 8503 8.611267e+00
R_8503_8603 8503 8603 5.479709e+00
R_8603_8703 8603 8703 3.746630e+00
R_8703_8803 8703 8803 8.796500e+00
R_8803_8903 8803 8903 3.030440e+00
R_8903_9003 8903 9003 4.473848e+00
R_9003_9103 9003 9103 1.980427e+00
R_9103_9203 9103 9203 1.371714e+00
R_9203_9303 9203 9303 5.825386e+00
R_9303_9403 9303 9403 6.033774e+00
R_9403_9503 9403 9503 5.376445e+00
R_9503_9603 9503 9603 5.046689e+00
R_9603_9703 9603 9703 7.888888e+00
R_9703_9803 9703 9803 6.936521e+00
R_9803_9903 9803 9903 5.233586e+00
R_4_104 4 104 4.098424e+00
R_104_204 104 204 5.293373e+00
R_204_304 204 304 6.620204e+00
R_304_404 304 404 1.540983e+00
R_404_504 404 504 9.514539e+00
R_504_604 504 604 7.480124e+00
R_604_704 604 704 4.817765e+00
R_704_804 704 804 1.134366e-03
R_804_904 804 904 1.204476e+00
R_904_1004 904 1004 5.534596e+00
R_1004_1104 1004 1104 3.761582e+00
R_1104_1204 1104 1204 4.849342e+00
R_1204_1304 1204 1304 9.552732e+00
R_1304_1404 1304 1404 1.763992e+00
R_1404_1504 1404 1504 2.938911e-01
R_1504_1604 1504 1604 9.334637e-01
R_1604_1704 1604 1704 2.305459e+00
R_1704_1804 1704 1804 7.832361e+00
R_1804_1904 1804 1904 4.395158e+00
R_1904_2004 1904 2004 1.230963e+00
R_2004_2104 2004 2104 8.353127e+00
R_2104_2204 2104 2204 3.216399e+00
R_2204_2304 2204 2304 9.771575e+00
R_2304_2404 2304 2404 6.083757e-01
R_2404_2504 2404 2504 8.035414e+00
R_2504_2604 2504 2604 6.527248e+00
R_2604_2704 2604 2704 3.944051e+00
R_2704_2804 2704 2804 3.371722e+00
R_2804_2904 2804 2904 2.661638e+00
R_2904_3004 2904 3004 2.191503e+00
R_3004_3104 3004 3104 6.564409e+00
R_3104_3204 3104 3204 3.385159e+00
R_3204_3304 3204 3304 4.172206e-01
R_3304_3404 3304 3404 3.711923e+00
R_3404_3504 3404 3504 8.651464e+00
R_3504_3604 3504 3604 8.040983e+00
R_3604_3704 3604 3704 3.341129e+00
R_3704_3804 3704 3804 9.665404e+00
R_3804_3904 3804 3904 7.079089e+00
R_3904_4004 3904 4004 2.566102e+00
R_4004_4104 4004 4104 1.055053e+00
R_4104_4204 4104 4204 1.059673e+00
R_4204_4304 4204 4304 8.878541e+00
R_4304_4404 4304 4404 5.112380e+00
R_4404_4504 4404 4504 8.247493e+00
R_4504_4604 4504 4604 8.202536e+00
R_4604_4704 4604 4704 4.099300e+00
R_4704_4804 4704 4804 4.948899e+00
R_4804_4904 4804 4904 9.008440e+00
R_4904_5004 4904 5004 1.007075e+00
R_5004_5104 5004 5104 7.989705e+00
R_5104_5204 5104 5204 7.930022e-01
R_5204_5304 5204 5304 2.985141e+00
R_5304_5404 5304 5404 5.415535e-01
R_5404_5504 5404 5504 5.942388e+00
R_5504_5604 5504 5604 2.374529e+00
R_5604_5704 5604 5704 3.223437e+00
R_5704_5804 5704 5804 3.843130e+00
R_5804_5904 5804 5904 9.446592e+00
R_5904_6004 5904 6004 1.327952e+00
R_6004_6104 6004 6104 4.735673e+00
R_6104_6204 6104 6204 4.036040e+00
R_6204_6304 6204 6304 8.108786e+00
R_6304_6404 6304 6404 4.364209e-01
R_6404_6504 6404 6504 7.597986e+00
R_6504_6604 6504 6604 5.208357e+00
R_6604_6704 6604 6704 4.950967e+00
R_6704_6804 6704 6804 2.917448e+00
R_6804_6904 6804 6904 2.313647e-01
R_6904_7004 6904 7004 5.225612e+00
R_7004_7104 7004 7104 9.115686e+00
R_7104_7204 7104 7204 1.660559e+00
R_7204_7304 7204 7304 1.723704e-01
R_7304_7404 7304 7404 2.879950e+00
R_7404_7504 7404 7504 3.734067e+00
R_7504_7604 7504 7604 1.091215e+00
R_7604_7704 7604 7704 1.505997e+00
R_7704_7804 7704 7804 2.577135e+00
R_7804_7904 7804 7904 7.087628e-01
R_7904_8004 7904 8004 4.392401e+00
R_8004_8104 8004 8104 1.090075e+00
R_8104_8204 8104 8204 6.033199e+00
R_8204_8304 8204 8304 4.384553e+00
R_8304_8404 8304 8404 9.784599e+00
R_8404_8504 8404 8504 7.369919e+00
R_8504_8604 8504 8604 9.368955e+00
R_8604_8704 8604 8704 8.529234e+00
R_8704_8804 8704 8804 7.266928e+00
R_8804_8904 8804 8904 2.990720e+00
R_8904_9004 8904 9004 8.916809e+00
R_9004_9104 9004 9104 5.956907e-01
R_9104_9204 9104 9204 4.659079e+00
R_9204_9304 9204 9304 3.735819e+00
R_9304_9404 9304 9404 9.283409e+00
R_9404_9504 9404 9504 4.471325e+00
R_9504_9604 9504 9604 5.017881e+00
R_9604_9704 9604 9704 9.675081e+00
R_9704_9804 9704 9804 2.172395e+00
R_9804_9904 9804 9904 5.913779e+00
R_5_105 5 105 9.295810e+00
R_105_205 105 205 6.342377e+00
R_205_305 205 305 7.906912e+00
R_305_405 305 405 3.348232e+00
R_405_505 405 505 7.910447e+00
R_505_605 505 605 5.306052e+00
R_605_705 605 705 8.784026e-01
R_705_805 705 805 4.685830e-01
R_805_905 805 905 9.802204e+00
R_905_1005 905 1005 6.249548e+00
R_1005_1105 1005 1105 4.797267e+00
R_1105_1205 1105 1205 8.749189e+00
R_1205_1305 1205 1305 6.435520e+00
R_1305_1405 1305 1405 2.438247e-01
R_1405_1505 1405 1505 9.485499e+00
R_1505_1605 1505 1605 2.441216e+00
R_1605_1705 1605 1705 9.943519e+00
R_1705_1805 1705 1805 4.597664e+00
R_1805_1905 1805 1905 1.738174e+00
R_1905_2005 1905 2005 5.162732e+00
R_2005_2105 2005 2105 3.121925e+00
R_2105_2205 2105 2205 1.707658e+00
R_2205_2305 2205 2305 8.981985e+00
R_2305_2405 2305 2405 6.119253e+00
R_2405_2505 2405 2505 3.373087e+00
R_2505_2605 2505 2605 1.334604e-01
R_2605_2705 2605 2705 3.229830e-01
R_2705_2805 2705 2805 3.050278e+00
R_2805_2905 2805 2905 4.047517e+00
R_2905_3005 2905 3005 8.844487e+00
R_3005_3105 3005 3105 3.989280e+00
R_3105_3205 3105 3205 4.522104e+00
R_3205_3305 3205 3305 6.687686e+00
R_3305_3405 3305 3405 4.371933e+00
R_3405_3505 3405 3505 4.761917e-01
R_3505_3605 3505 3605 7.268983e+00
R_3605_3705 3605 3705 8.682525e+00
R_3705_3805 3705 3805 2.086516e+00
R_3805_3905 3805 3905 8.619711e-01
R_3905_4005 3905 4005 8.465316e+00
R_4005_4105 4005 4105 6.346014e+00
R_4105_4205 4105 4205 7.631543e-01
R_4205_4305 4205 4305 9.557670e+00
R_4305_4405 4305 4405 9.132849e+00
R_4405_4505 4405 4505 9.200857e+00
R_4505_4605 4505 4605 3.605009e+00
R_4605_4705 4605 4705 9.242083e+00
R_4705_4805 4705 4805 2.439836e+00
R_4805_4905 4805 4905 6.206746e+00
R_4905_5005 4905 5005 2.371097e+00
R_5005_5105 5005 5105 7.733539e+00
R_5105_5205 5105 5205 7.466919e+00
R_5205_5305 5205 5305 1.816322e+00
R_5305_5405 5305 5405 6.447174e+00
R_5405_5505 5405 5505 2.670013e+00
R_5505_5605 5505 5605 8.293465e+00
R_5605_5705 5605 5705 3.506267e-01
R_5705_5805 5705 5805 5.749621e+00
R_5805_5905 5805 5905 9.431378e+00
R_5905_6005 5905 6005 5.508525e-01
R_6005_6105 6005 6105 4.161969e+00
R_6105_6205 6105 6205 9.476392e+00
R_6205_6305 6205 6305 7.922733e-01
R_6305_6405 6305 6405 6.020087e+00
R_6405_6505 6405 6505 3.477465e+00
R_6505_6605 6505 6605 2.463723e-02
R_6605_6705 6605 6705 4.836389e-01
R_6705_6805 6705 6805 4.443259e+00
R_6805_6905 6805 6905 3.718365e+00
R_6905_7005 6905 7005 3.021558e+00
R_7005_7105 7005 7105 2.465694e+00
R_7105_7205 7105 7205 4.474154e+00
R_7205_7305 7205 7305 3.479515e+00
R_7305_7405 7305 7405 1.622369e+00
R_7405_7505 7405 7505 4.988199e+00
R_7505_7605 7505 7605 7.563228e+00
R_7605_7705 7605 7705 1.819983e+00
R_7705_7805 7705 7805 1.609356e+00
R_7805_7905 7805 7905 8.215354e+00
R_7905_8005 7905 8005 7.160230e+00
R_8005_8105 8005 8105 3.351518e+00
R_8105_8205 8105 8205 6.019157e+00
R_8205_8305 8205 8305 4.524797e+00
R_8305_8405 8305 8405 7.208521e+00
R_8405_8505 8405 8505 4.356145e+00
R_8505_8605 8505 8605 8.611364e+00
R_8605_8705 8605 8705 6.001023e+00
R_8705_8805 8705 8805 4.122685e+00
R_8805_8905 8805 8905 6.311520e+00
R_8905_9005 8905 9005 3.651092e-01
R_9005_9105 9005 9105 1.817331e+00
R_9105_9205 9105 9205 3.633813e-01
R_9205_9305 9205 9305 3.185627e+00
R_9305_9405 9305 9405 9.754711e+00
R_9405_9505 9405 9505 9.706830e+00
R_9505_9605 9505 9605 9.591239e-01
R_9605_9705 9605 9705 8.761785e+00
R_9705_9805 9705 9805 7.359789e+00
R_9805_9905 9805 9905 9.792371e+00
R_6_106 6 106 7.442726e+00
R_106_206 106 206 9.497615e+00
R_206_306 206 306 7.456554e+00
R_306_406 306 406 3.418325e+00
R_406_506 406 506 7.193187e+00
R_506_606 506 606 6.222830e+00
R_606_706 606 706 4.110705e+00
R_706_806 706 806 3.188277e+00
R_806_906 806 906 4.569664e+00
R_906_1006 906 1006 7.870399e+00
R_1006_1106 1006 1106 9.407240e+00
R_1106_1206 1106 1206 1.928133e+00
R_1206_1306 1206 1306 8.327006e+00
R_1306_1406 1306 1406 2.561254e+00
R_1406_1506 1406 1506 5.401203e+00
R_1506_1606 1506 1606 7.470870e+00
R_1606_1706 1606 1706 7.378579e+00
R_1706_1806 1706 1806 1.404807e+00
R_1806_1906 1806 1906 5.793475e+00
R_1906_2006 1906 2006 4.382848e-01
R_2006_2106 2006 2106 6.522676e+00
R_2106_2206 2106 2206 9.619860e-01
R_2206_2306 2206 2306 6.879946e+00
R_2306_2406 2306 2406 7.917834e+00
R_2406_2506 2406 2506 5.782982e-01
R_2506_2606 2506 2606 3.796150e+00
R_2606_2706 2606 2706 8.236297e+00
R_2706_2806 2706 2806 9.625842e+00
R_2806_2906 2806 2906 3.171225e+00
R_2906_3006 2906 3006 1.533878e+00
R_3006_3106 3006 3106 4.286148e+00
R_3106_3206 3106 3206 7.720999e-01
R_3206_3306 3206 3306 4.645446e+00
R_3306_3406 3306 3406 8.967867e+00
R_3406_3506 3406 3506 5.876222e+00
R_3506_3606 3506 3606 6.781244e-01
R_3606_3706 3606 3706 7.387106e+00
R_3706_3806 3706 3806 6.385684e+00
R_3806_3906 3806 3906 7.917081e+00
R_3906_4006 3906 4006 4.010753e+00
R_4006_4106 4006 4106 7.460701e+00
R_4106_4206 4106 4206 8.110855e+00
R_4206_4306 4206 4306 9.759544e+00
R_4306_4406 4306 4406 4.415698e+00
R_4406_4506 4406 4506 1.398855e+00
R_4506_4606 4506 4606 1.310148e+00
R_4606_4706 4606 4706 4.240058e-01
R_4706_4806 4706 4806 6.730151e+00
R_4806_4906 4806 4906 2.867768e+00
R_4906_5006 4906 5006 3.100999e+00
R_5006_5106 5006 5106 4.598047e+00
R_5106_5206 5106 5206 8.731866e+00
R_5206_5306 5206 5306 1.367370e+00
R_5306_5406 5306 5406 4.574970e-01
R_5406_5506 5406 5506 3.521382e+00
R_5506_5606 5506 5606 8.056957e+00
R_5606_5706 5606 5706 4.612369e+00
R_5706_5806 5706 5806 5.715743e+00
R_5806_5906 5806 5906 5.760469e+00
R_5906_6006 5906 6006 2.744628e+00
R_6006_6106 6006 6106 3.584556e+00
R_6106_6206 6106 6206 2.715817e+00
R_6206_6306 6206 6306 9.553866e-01
R_6306_6406 6306 6406 2.024359e+00
R_6406_6506 6406 6506 5.439710e+00
R_6506_6606 6506 6606 5.833934e+00
R_6606_6706 6606 6706 5.269602e+00
R_6706_6806 6706 6806 8.860219e+00
R_6806_6906 6806 6906 1.807769e+00
R_6906_7006 6906 7006 4.374039e+00
R_7006_7106 7006 7106 9.819506e+00
R_7106_7206 7106 7206 2.735183e+00
R_7206_7306 7206 7306 4.520907e+00
R_7306_7406 7306 7406 3.522647e+00
R_7406_7506 7406 7506 8.247484e-01
R_7506_7606 7506 7606 6.404179e-01
R_7606_7706 7606 7706 4.451733e+00
R_7706_7806 7706 7806 4.805058e+00
R_7806_7906 7806 7906 1.873111e+00
R_7906_8006 7906 8006 2.595828e+00
R_8006_8106 8006 8106 9.166070e+00
R_8106_8206 8106 8206 3.770247e+00
R_8206_8306 8206 8306 4.620695e+00
R_8306_8406 8306 8406 7.204816e+00
R_8406_8506 8406 8506 8.680696e+00
R_8506_8606 8506 8606 6.540823e+00
R_8606_8706 8606 8706 8.064882e+00
R_8706_8806 8706 8806 2.547002e-01
R_8806_8906 8806 8906 4.609217e-01
R_8906_9006 8906 9006 5.939882e+00
R_9006_9106 9006 9106 8.510339e+00
R_9106_9206 9106 9206 3.401764e-01
R_9206_9306 9206 9306 7.512181e+00
R_9306_9406 9306 9406 5.628245e+00
R_9406_9506 9406 9506 9.097231e+00
R_9506_9606 9506 9606 3.399484e+00
R_9606_9706 9606 9706 9.603011e+00
R_9706_9806 9706 9806 3.653808e+00
R_9806_9906 9806 9906 5.369851e+00
R_7_107 7 107 5.412247e+00
R_107_207 107 207 1.212354e+00
R_207_307 207 307 7.632285e+00
R_307_407 307 407 3.160450e+00
R_407_507 407 507 5.689685e+00
R_507_607 507 607 6.819264e+00
R_607_707 607 707 1.170123e+00
R_707_807 707 807 9.004353e+00
R_807_907 807 907 7.230139e-01
R_907_1007 907 1007 1.813841e+00
R_1007_1107 1007 1107 7.684330e+00
R_1107_1207 1107 1207 1.262503e-01
R_1207_1307 1207 1307 1.566793e+00
R_1307_1407 1307 1407 1.989193e+00
R_1407_1507 1407 1507 5.404314e+00
R_1507_1607 1507 1607 2.377563e+00
R_1607_1707 1607 1707 1.892146e+00
R_1707_1807 1707 1807 8.318346e+00
R_1807_1907 1807 1907 1.420804e+00
R_1907_2007 1907 2007 2.362856e+00
R_2007_2107 2007 2107 7.547885e+00
R_2107_2207 2107 2207 5.269432e+00
R_2207_2307 2207 2307 5.016305e+00
R_2307_2407 2307 2407 6.676646e+00
R_2407_2507 2407 2507 7.437498e+00
R_2507_2607 2507 2607 4.542681e+00
R_2607_2707 2607 2707 7.045641e+00
R_2707_2807 2707 2807 4.232495e+00
R_2807_2907 2807 2907 9.636862e+00
R_2907_3007 2907 3007 2.124560e+00
R_3007_3107 3007 3107 5.163127e+00
R_3107_3207 3107 3207 4.741298e+00
R_3207_3307 3207 3307 1.195819e+00
R_3307_3407 3307 3407 6.635548e+00
R_3407_3507 3407 3507 8.631506e+00
R_3507_3607 3507 3607 4.545660e-01
R_3607_3707 3607 3707 7.608122e+00
R_3707_3807 3707 3807 9.709820e+00
R_3807_3907 3807 3907 3.767536e+00
R_3907_4007 3907 4007 7.163578e+00
R_4007_4107 4007 4107 1.004177e+00
R_4107_4207 4107 4207 2.897998e+00
R_4207_4307 4207 4307 6.443630e+00
R_4307_4407 4307 4407 6.786302e+00
R_4407_4507 4407 4507 6.678370e+00
R_4507_4607 4507 4607 2.227836e+00
R_4607_4707 4607 4707 9.868726e+00
R_4707_4807 4707 4807 1.671659e+00
R_4807_4907 4807 4907 2.721279e-01
R_4907_5007 4907 5007 4.802717e+00
R_5007_5107 5007 5107 5.311960e+00
R_5107_5207 5107 5207 3.955001e+00
R_5207_5307 5207 5307 7.836439e+00
R_5307_5407 5307 5407 3.418160e+00
R_5407_5507 5407 5507 6.903631e+00
R_5507_5607 5507 5607 5.702625e+00
R_5607_5707 5607 5707 1.107828e+00
R_5707_5807 5707 5807 3.136203e+00
R_5807_5907 5807 5907 1.637493e-01
R_5907_6007 5907 6007 8.475975e+00
R_6007_6107 6007 6107 7.799481e+00
R_6107_6207 6107 6207 2.577562e+00
R_6207_6307 6207 6307 1.286623e+00
R_6307_6407 6307 6407 7.583545e+00
R_6407_6507 6407 6507 3.193021e+00
R_6507_6607 6507 6607 2.594671e+00
R_6607_6707 6607 6707 5.930633e+00
R_6707_6807 6707 6807 1.311119e+00
R_6807_6907 6807 6907 8.461506e+00
R_6907_7007 6907 7007 1.987529e+00
R_7007_7107 7007 7107 4.848063e+00
R_7107_7207 7107 7207 2.386318e+00
R_7207_7307 7207 7307 6.267703e-01
R_7307_7407 7307 7407 3.225391e+00
R_7407_7507 7407 7507 6.311266e+00
R_7507_7607 7507 7607 4.086844e+00
R_7607_7707 7607 7707 7.391513e-01
R_7707_7807 7707 7807 4.406916e+00
R_7807_7907 7807 7907 7.612639e+00
R_7907_8007 7907 8007 4.078633e+00
R_8007_8107 8007 8107 2.495125e+00
R_8107_8207 8107 8207 8.346178e+00
R_8207_8307 8207 8307 9.284798e-01
R_8307_8407 8307 8407 8.079673e+00
R_8407_8507 8407 8507 9.803628e+00
R_8507_8607 8507 8607 7.201716e+00
R_8607_8707 8607 8707 1.452542e+00
R_8707_8807 8707 8807 6.152610e+00
R_8807_8907 8807 8907 2.448410e+00
R_8907_9007 8907 9007 7.988630e+00
R_9007_9107 9007 9107 2.144978e+00
R_9107_9207 9107 9207 7.684035e+00
R_9207_9307 9207 9307 3.087035e+00
R_9307_9407 9307 9407 9.862666e+00
R_9407_9507 9407 9507 1.754251e+00
R_9507_9607 9507 9607 1.729797e+00
R_9607_9707 9607 9707 3.769275e+00
R_9707_9807 9707 9807 1.151060e+00
R_9807_9907 9807 9907 2.160708e+00
R_8_108 8 108 6.454224e+00
R_108_208 108 208 7.453864e-03
R_208_308 208 308 3.485349e+00
R_308_408 308 408 7.477440e+00
R_408_508 408 508 1.856564e+00
R_508_608 508 608 5.374260e+00
R_608_708 608 708 4.438011e-01
R_708_808 708 808 6.101017e+00
R_808_908 808 908 3.279701e+00
R_908_1008 908 1008 2.491997e+00
R_1008_1108 1008 1108 2.872600e+00
R_1108_1208 1108 1208 8.064619e+00
R_1208_1308 1208 1308 8.217820e+00
R_1308_1408 1308 1408 2.172104e+00
R_1408_1508 1408 1508 3.152375e+00
R_1508_1608 1508 1608 5.534508e+00
R_1608_1708 1608 1708 6.716027e+00
R_1708_1808 1708 1808 1.091544e+00
R_1808_1908 1808 1908 7.284019e+00
R_1908_2008 1908 2008 5.289081e+00
R_2008_2108 2008 2108 9.483130e+00
R_2108_2208 2108 2208 5.291647e+00
R_2208_2308 2208 2308 2.979585e+00
R_2308_2408 2308 2408 4.529988e+00
R_2408_2508 2408 2508 1.992054e+00
R_2508_2608 2508 2608 8.741567e+00
R_2608_2708 2608 2708 5.034523e+00
R_2708_2808 2708 2808 6.990329e-01
R_2808_2908 2808 2908 6.253318e+00
R_2908_3008 2908 3008 9.346686e+00
R_3008_3108 3008 3108 6.614757e+00
R_3108_3208 3108 3208 4.743130e-01
R_3208_3308 3208 3308 7.293092e+00
R_3308_3408 3308 3408 4.815760e+00
R_3408_3508 3408 3508 8.679361e+00
R_3508_3608 3508 3608 9.012737e+00
R_3608_3708 3608 3708 9.673321e+00
R_3708_3808 3708 3808 2.894165e+00
R_3808_3908 3808 3908 1.968437e+00
R_3908_4008 3908 4008 1.885018e+00
R_4008_4108 4008 4108 5.428779e+00
R_4108_4208 4108 4208 4.462838e+00
R_4208_4308 4208 4308 5.363923e+00
R_4308_4408 4308 4408 7.502956e+00
R_4408_4508 4408 4508 7.356812e+00
R_4508_4608 4508 4608 2.952251e+00
R_4608_4708 4608 4708 7.994216e-01
R_4708_4808 4708 4808 8.034193e+00
R_4808_4908 4808 4908 5.487607e+00
R_4908_5008 4908 5008 2.514955e+00
R_5008_5108 5008 5108 6.340138e+00
R_5108_5208 5108 5208 6.710260e+00
R_5208_5308 5208 5308 6.560677e+00
R_5308_5408 5308 5408 6.939043e-01
R_5408_5508 5408 5508 9.198225e+00
R_5508_5608 5508 5608 1.083412e+00
R_5608_5708 5608 5708 8.300713e+00
R_5708_5808 5708 5808 3.749286e+00
R_5808_5908 5808 5908 2.738267e+00
R_5908_6008 5908 6008 6.652751e+00
R_6008_6108 6008 6108 5.996185e+00
R_6108_6208 6108 6208 8.851084e+00
R_6208_6308 6208 6308 2.526875e+00
R_6308_6408 6308 6408 8.067917e-01
R_6408_6508 6408 6508 5.747321e+00
R_6508_6608 6508 6608 1.575628e+00
R_6608_6708 6608 6708 5.983695e+00
R_6708_6808 6708 6808 2.918154e-01
R_6808_6908 6808 6908 8.934028e-01
R_6908_7008 6908 7008 5.545936e+00
R_7008_7108 7008 7108 8.064902e+00
R_7108_7208 7108 7208 9.008334e+00
R_7208_7308 7208 7308 9.331934e-01
R_7308_7408 7308 7408 2.963080e+00
R_7408_7508 7408 7508 3.863107e+00
R_7508_7608 7508 7608 7.134067e+00
R_7608_7708 7608 7708 1.815256e+00
R_7708_7808 7708 7808 6.974720e-02
R_7808_7908 7808 7908 5.279883e-01
R_7908_8008 7908 8008 7.379773e+00
R_8008_8108 8008 8108 9.423786e+00
R_8108_8208 8108 8208 1.761576e+00
R_8208_8308 8208 8308 3.058243e-02
R_8308_8408 8308 8408 6.020347e+00
R_8408_8508 8408 8508 9.065840e+00
R_8508_8608 8508 8608 8.738802e+00
R_8608_8708 8608 8708 2.163576e+00
R_8708_8808 8708 8808 7.879178e-01
R_8808_8908 8808 8908 7.139779e+00
R_8908_9008 8908 9008 8.130470e+00
R_9008_9108 9008 9108 6.950077e+00
R_9108_9208 9108 9208 1.808079e+00
R_9208_9308 9208 9308 2.444557e+00
R_9308_9408 9308 9408 7.924629e+00
R_9408_9508 9408 9508 4.876798e+00
R_9508_9608 9508 9608 7.448173e+00
R_9608_9708 9608 9708 1.739528e+00
R_9708_9808 9708 9808 4.203388e+00
R_9808_9908 9808 9908 4.940084e-01
R_9_109 9 109 1.328060e+00
R_109_209 109 209 4.566064e+00
R_209_309 209 309 3.559515e+00
R_309_409 309 409 1.965908e+00
R_409_509 409 509 4.761611e+00
R_509_609 509 609 4.383791e+00
R_609_709 609 709 3.930981e+00
R_709_809 709 809 4.276410e+00
R_809_909 809 909 6.210602e+00
R_909_1009 909 1009 2.841666e+00
R_1009_1109 1009 1109 8.934414e+00
R_1109_1209 1109 1209 7.968626e-01
R_1209_1309 1209 1309 9.982387e+00
R_1309_1409 1309 1409 9.873718e+00
R_1409_1509 1409 1509 3.328031e+00
R_1509_1609 1509 1609 9.172658e+00
R_1609_1709 1609 1709 2.545811e+00
R_1709_1809 1709 1809 9.383156e+00
R_1809_1909 1809 1909 9.972475e+00
R_1909_2009 1909 2009 5.258373e+00
R_2009_2109 2009 2109 9.605108e+00
R_2109_2209 2109 2209 5.984028e+00
R_2209_2309 2209 2309 4.263034e-01
R_2309_2409 2309 2409 1.400743e+00
R_2409_2509 2409 2509 1.175776e+00
R_2509_2609 2509 2609 7.142729e+00
R_2609_2709 2609 2709 6.383866e+00
R_2709_2809 2709 2809 8.435521e+00
R_2809_2909 2809 2909 4.096534e+00
R_2909_3009 2909 3009 4.981086e+00
R_3009_3109 3009 3109 5.717160e+00
R_3109_3209 3109 3209 1.703295e+00
R_3209_3309 3209 3309 8.495491e-02
R_3309_3409 3309 3409 6.930247e+00
R_3409_3509 3409 3509 4.289013e+00
R_3509_3609 3509 3609 3.352314e+00
R_3609_3709 3609 3709 5.491220e+00
R_3709_3809 3709 3809 8.099930e+00
R_3809_3909 3809 3909 6.733518e+00
R_3909_4009 3909 4009 1.463480e+00
R_4009_4109 4009 4109 9.974051e+00
R_4109_4209 4109 4209 2.202051e+00
R_4209_4309 4209 4309 1.897910e+00
R_4309_4409 4309 4409 7.997903e+00
R_4409_4509 4409 4509 2.568819e+00
R_4509_4609 4509 4609 4.766561e-01
R_4609_4709 4609 4709 6.225224e+00
R_4709_4809 4709 4809 9.831000e+00
R_4809_4909 4809 4909 6.267630e+00
R_4909_5009 4909 5009 3.359904e+00
R_5009_5109 5009 5109 5.146970e-01
R_5109_5209 5109 5209 2.176765e+00
R_5209_5309 5209 5309 8.900349e+00
R_5309_5409 5309 5409 4.787100e+00
R_5409_5509 5409 5509 6.108388e-02
R_5509_5609 5509 5609 2.973231e-01
R_5609_5709 5609 5709 5.545324e+00
R_5709_5809 5709 5809 6.225378e+00
R_5809_5909 5809 5909 6.509386e+00
R_5909_6009 5909 6009 8.704167e+00
R_6009_6109 6009 6109 1.898511e+00
R_6109_6209 6109 6209 7.455497e+00
R_6209_6309 6209 6309 2.283631e+00
R_6309_6409 6309 6409 7.360721e+00
R_6409_6509 6409 6509 3.675213e+00
R_6509_6609 6509 6609 1.353859e+00
R_6609_6709 6609 6709 5.737804e+00
R_6709_6809 6709 6809 5.256034e+00
R_6809_6909 6809 6909 6.538639e+00
R_6909_7009 6909 7009 4.348482e+00
R_7009_7109 7009 7109 7.931444e+00
R_7109_7209 7109 7209 5.472519e+00
R_7209_7309 7209 7309 2.476933e-01
R_7309_7409 7309 7409 7.151716e+00
R_7409_7509 7409 7509 3.282386e+00
R_7509_7609 7509 7609 2.553643e+00
R_7609_7709 7609 7709 4.055746e+00
R_7709_7809 7709 7809 1.431985e-01
R_7809_7909 7809 7909 5.594774e-01
R_7909_8009 7909 8009 9.009978e+00
R_8009_8109 8009 8109 7.863224e+00
R_8109_8209 8109 8209 5.493450e+00
R_8209_8309 8209 8309 9.682623e+00
R_8309_8409 8309 8409 6.258574e+00
R_8409_8509 8409 8509 5.187900e+00
R_8509_8609 8509 8609 7.512383e-01
R_8609_8709 8609 8709 4.615354e-02
R_8709_8809 8709 8809 2.639185e+00
R_8809_8909 8809 8909 3.160982e+00
R_8909_9009 8909 9009 9.461831e+00
R_9009_9109 9009 9109 9.781822e+00
R_9109_9209 9109 9209 2.412596e+00
R_9209_9309 9209 9309 7.609339e+00
R_9309_9409 9309 9409 5.303800e+00
R_9409_9509 9409 9509 4.157857e+00
R_9509_9609 9509 9609 6.776713e+00
R_9609_9709 9609 9709 3.939873e+00
R_9709_9809 9709 9809 7.157350e-01
R_9809_9909 9809 9909 6.283894e+00
R_10_110 10 110 8.649550e+00
R_110_210 110 210 4.674422e+00
R_210_310 210 310 5.796528e+00
R_310_410 310 410 9.093628e+00
R_410_510 410 510 1.844212e+00
R_510_610 510 610 6.379164e+00
R_610_710 610 710 7.384899e+00
R_710_810 710 810 5.135471e+00
R_810_910 810 910 2.280175e+00
R_910_1010 910 1010 2.542177e+00
R_1010_1110 1010 1110 6.080847e+00
R_1110_1210 1110 1210 1.560444e-01
R_1210_1310 1210 1310 2.815481e+00
R_1310_1410 1310 1410 8.398899e-01
R_1410_1510 1410 1510 7.970465e-01
R_1510_1610 1510 1610 4.467849e+00
R_1610_1710 1610 1710 9.028886e+00
R_1710_1810 1710 1810 6.877267e+00
R_1810_1910 1810 1910 4.012931e+00
R_1910_2010 1910 2010 2.279862e+00
R_2010_2110 2010 2110 3.653099e+00
R_2110_2210 2110 2210 9.030755e+00
R_2210_2310 2210 2310 8.599858e+00
R_2310_2410 2310 2410 5.998855e+00
R_2410_2510 2410 2510 3.255177e+00
R_2510_2610 2510 2610 6.612433e+00
R_2610_2710 2610 2710 2.497441e+00
R_2710_2810 2710 2810 6.350193e+00
R_2810_2910 2810 2910 3.308304e+00
R_2910_3010 2910 3010 7.141073e+00
R_3010_3110 3010 3110 2.094486e+00
R_3110_3210 3110 3210 6.351417e+00
R_3210_3310 3210 3310 3.636686e+00
R_3310_3410 3310 3410 4.513267e+00
R_3410_3510 3410 3510 1.201503e+00
R_3510_3610 3510 3610 5.707617e+00
R_3610_3710 3610 3710 7.302934e-01
R_3710_3810 3710 3810 8.788343e+00
R_3810_3910 3810 3910 5.107121e+00
R_3910_4010 3910 4010 9.408137e-01
R_4010_4110 4010 4110 1.821452e+00
R_4110_4210 4110 4210 5.980329e-01
R_4210_4310 4210 4310 3.475399e+00
R_4310_4410 4310 4410 8.806315e+00
R_4410_4510 4410 4510 3.896468e+00
R_4510_4610 4510 4610 4.124197e+00
R_4610_4710 4610 4710 8.298323e+00
R_4710_4810 4710 4810 8.453526e+00
R_4810_4910 4810 4910 3.852715e+00
R_4910_5010 4910 5010 2.835178e+00
R_5010_5110 5010 5110 9.888712e+00
R_5110_5210 5110 5210 6.756725e+00
R_5210_5310 5210 5310 7.059191e+00
R_5310_5410 5310 5410 4.393508e+00
R_5410_5510 5410 5510 7.101297e+00
R_5510_5610 5510 5610 1.079360e+00
R_5610_5710 5610 5710 4.256532e+00
R_5710_5810 5710 5810 1.297888e+00
R_5810_5910 5810 5910 9.191298e-01
R_5910_6010 5910 6010 9.336678e+00
R_6010_6110 6010 6110 5.905913e+00
R_6110_6210 6110 6210 3.911818e+00
R_6210_6310 6210 6310 6.119338e+00
R_6310_6410 6310 6410 7.358224e+00
R_6410_6510 6410 6510 7.024479e+00
R_6510_6610 6510 6610 3.689171e-01
R_6610_6710 6610 6710 8.502708e+00
R_6710_6810 6710 6810 5.838296e+00
R_6810_6910 6810 6910 2.358563e-01
R_6910_7010 6910 7010 3.616814e+00
R_7010_7110 7010 7110 2.842194e+00
R_7110_7210 7110 7210 8.142220e+00
R_7210_7310 7210 7310 4.602469e+00
R_7310_7410 7310 7410 9.203056e+00
R_7410_7510 7410 7510 3.775340e+00
R_7510_7610 7510 7610 1.891948e+00
R_7610_7710 7610 7710 5.739079e+00
R_7710_7810 7710 7810 1.788226e+00
R_7810_7910 7810 7910 9.497877e+00
R_7910_8010 7910 8010 3.288019e+00
R_8010_8110 8010 8110 1.015769e+00
R_8110_8210 8110 8210 3.082833e+00
R_8210_8310 8210 8310 9.692378e+00
R_8310_8410 8310 8410 4.195064e-01
R_8410_8510 8410 8510 6.222854e+00
R_8510_8610 8510 8610 3.402250e+00
R_8610_8710 8610 8710 6.511496e+00
R_8710_8810 8710 8810 1.291062e+00
R_8810_8910 8810 8910 9.503796e+00
R_8910_9010 8910 9010 7.809935e+00
R_9010_9110 9010 9110 1.834212e+00
R_9110_9210 9110 9210 8.392469e-01
R_9210_9310 9210 9310 8.394334e+00
R_9310_9410 9310 9410 9.487668e+00
R_9410_9510 9410 9510 6.870102e+00
R_9510_9610 9510 9610 1.914809e+00
R_9610_9710 9610 9710 4.078869e+00
R_9710_9810 9710 9810 7.389211e+00
R_9810_9910 9810 9910 9.425879e+00
R_11_111 11 111 5.973516e+00
R_111_211 111 211 5.555874e+00
R_211_311 211 311 9.729082e+00
R_311_411 311 411 3.124895e+00
R_411_511 411 511 9.099288e+00
R_511_611 511 611 6.457000e+00
R_611_711 611 711 7.729030e+00
R_711_811 711 811 4.192314e+00
R_811_911 811 911 2.408457e+00
R_911_1011 911 1011 4.659943e+00
R_1011_1111 1011 1111 8.303507e+00
R_1111_1211 1111 1211 6.771900e+00
R_1211_1311 1211 1311 3.471960e+00
R_1311_1411 1311 1411 2.181565e+00
R_1411_1511 1411 1511 7.302146e+00
R_1511_1611 1511 1611 3.224433e-01
R_1611_1711 1611 1711 2.371746e+00
R_1711_1811 1711 1811 9.254098e+00
R_1811_1911 1811 1911 9.164335e+00
R_1911_2011 1911 2011 4.956474e+00
R_2011_2111 2011 2111 3.040735e+00
R_2111_2211 2111 2211 8.166460e+00
R_2211_2311 2211 2311 5.860673e+00
R_2311_2411 2311 2411 5.971903e+00
R_2411_2511 2411 2511 9.762452e+00
R_2511_2611 2511 2611 6.472224e+00
R_2611_2711 2611 2711 7.976971e+00
R_2711_2811 2711 2811 2.422643e+00
R_2811_2911 2811 2911 6.022878e+00
R_2911_3011 2911 3011 3.606455e+00
R_3011_3111 3011 3111 2.202909e+00
R_3111_3211 3111 3211 9.184185e+00
R_3211_3311 3211 3311 1.867474e+00
R_3311_3411 3311 3411 7.248531e+00
R_3411_3511 3411 3511 3.361879e+00
R_3511_3611 3511 3611 1.566755e+00
R_3611_3711 3611 3711 3.125580e+00
R_3711_3811 3711 3811 7.060127e+00
R_3811_3911 3811 3911 6.422624e+00
R_3911_4011 3911 4011 7.579930e+00
R_4011_4111 4011 4111 4.080917e+00
R_4111_4211 4111 4211 3.743673e+00
R_4211_4311 4211 4311 5.371297e+00
R_4311_4411 4311 4411 9.621312e+00
R_4411_4511 4411 4511 6.283279e+00
R_4511_4611 4511 4611 2.055632e+00
R_4611_4711 4611 4711 1.505367e+00
R_4711_4811 4711 4811 1.260103e+00
R_4811_4911 4811 4911 4.087027e+00
R_4911_5011 4911 5011 9.608156e-01
R_5011_5111 5011 5111 3.393136e+00
R_5111_5211 5111 5211 9.376515e+00
R_5211_5311 5211 5311 7.413148e+00
R_5311_5411 5311 5411 4.508006e+00
R_5411_5511 5411 5511 1.622824e+00
R_5511_5611 5511 5611 5.207277e+00
R_5611_5711 5611 5711 6.856473e+00
R_5711_5811 5711 5811 1.031604e+00
R_5811_5911 5811 5911 8.713647e-01
R_5911_6011 5911 6011 8.971404e+00
R_6011_6111 6011 6111 7.945525e+00
R_6111_6211 6111 6211 1.327413e+00
R_6211_6311 6211 6311 7.385084e+00
R_6311_6411 6311 6411 1.404813e+00
R_6411_6511 6411 6511 3.227637e+00
R_6511_6611 6511 6611 9.961510e-03
R_6611_6711 6611 6711 9.215307e+00
R_6711_6811 6711 6811 9.061662e+00
R_6811_6911 6811 6911 7.380129e+00
R_6911_7011 6911 7011 1.192109e+00
R_7011_7111 7011 7111 2.681619e+00
R_7111_7211 7111 7211 2.091429e+00
R_7211_7311 7211 7311 5.125972e+00
R_7311_7411 7311 7411 9.515128e+00
R_7411_7511 7411 7511 5.398440e-01
R_7511_7611 7511 7611 7.900939e+00
R_7611_7711 7611 7711 5.294382e+00
R_7711_7811 7711 7811 4.688034e+00
R_7811_7911 7811 7911 9.195488e+00
R_7911_8011 7911 8011 9.456413e+00
R_8011_8111 8011 8111 5.114443e+00
R_8111_8211 8111 8211 5.310671e-01
R_8211_8311 8211 8311 3.760249e+00
R_8311_8411 8311 8411 1.802571e+00
R_8411_8511 8411 8511 3.265894e+00
R_8511_8611 8511 8611 8.764912e+00
R_8611_8711 8611 8711 1.037922e-01
R_8711_8811 8711 8811 3.850687e+00
R_8811_8911 8811 8911 9.479402e+00
R_8911_9011 8911 9011 1.402391e+00
R_9011_9111 9011 9111 4.829327e+00
R_9111_9211 9111 9211 2.603270e+00
R_9211_9311 9211 9311 1.360710e+00
R_9311_9411 9311 9411 2.913042e+00
R_9411_9511 9411 9511 4.620242e+00
R_9511_9611 9511 9611 3.395939e+00
R_9611_9711 9611 9711 9.230037e+00
R_9711_9811 9711 9811 2.390938e+00
R_9811_9911 9811 9911 7.849627e+00
R_12_112 12 112 3.622243e+00
R_112_212 112 212 5.798699e+00
R_212_312 212 312 7.014950e+00
R_312_412 312 412 3.596430e+00
R_412_512 412 512 2.733972e+00
R_512_612 512 612 6.628134e+00
R_612_712 612 712 8.700917e+00
R_712_812 712 812 2.792392e+00
R_812_912 812 912 1.141823e+00
R_912_1012 912 1012 3.963989e+00
R_1012_1112 1012 1112 6.144375e+00
R_1112_1212 1112 1212 2.517745e+00
R_1212_1312 1212 1312 2.629753e+00
R_1312_1412 1312 1412 1.624259e+00
R_1412_1512 1412 1512 3.137863e+00
R_1512_1612 1512 1612 9.254866e-01
R_1612_1712 1612 1712 2.561528e-01
R_1712_1812 1712 1812 9.904671e-01
R_1812_1912 1812 1912 4.055981e+00
R_1912_2012 1912 2012 3.181934e-01
R_2012_2112 2012 2112 2.475052e+00
R_2112_2212 2112 2212 2.131977e-01
R_2212_2312 2212 2312 8.820767e+00
R_2312_2412 2312 2412 7.680423e+00
R_2412_2512 2412 2512 1.429223e+00
R_2512_2612 2512 2612 4.764911e+00
R_2612_2712 2612 2712 2.372406e+00
R_2712_2812 2712 2812 7.913485e+00
R_2812_2912 2812 2912 9.788161e+00
R_2912_3012 2912 3012 8.927733e+00
R_3012_3112 3012 3112 3.610800e+00
R_3112_3212 3112 3212 7.968791e+00
R_3212_3312 3212 3312 9.322147e+00
R_3312_3412 3312 3412 1.032163e+00
R_3412_3512 3412 3512 8.728653e+00
R_3512_3612 3512 3612 5.574729e+00
R_3612_3712 3612 3712 6.187236e+00
R_3712_3812 3712 3812 9.397885e-01
R_3812_3912 3812 3912 5.449681e+00
R_3912_4012 3912 4012 9.030594e+00
R_4012_4112 4012 4112 2.942189e+00
R_4112_4212 4112 4212 6.146053e+00
R_4212_4312 4212 4312 6.530265e+00
R_4312_4412 4312 4412 8.686205e+00
R_4412_4512 4412 4512 3.038772e+00
R_4512_4612 4512 4612 2.374587e+00
R_4612_4712 4612 4712 9.003099e+00
R_4712_4812 4712 4812 8.826110e+00
R_4812_4912 4812 4912 6.663078e+00
R_4912_5012 4912 5012 7.052016e+00
R_5012_5112 5012 5112 8.655647e+00
R_5112_5212 5112 5212 3.150246e+00
R_5212_5312 5212 5312 9.089856e+00
R_5312_5412 5312 5412 4.602557e+00
R_5412_5512 5412 5512 9.548302e-01
R_5512_5612 5512 5612 9.064270e+00
R_5612_5712 5612 5712 3.626044e+00
R_5712_5812 5712 5812 7.013170e-01
R_5812_5912 5812 5912 4.841165e+00
R_5912_6012 5912 6012 7.763934e+00
R_6012_6112 6012 6112 7.558351e+00
R_6112_6212 6112 6212 3.782961e-01
R_6212_6312 6212 6312 1.191763e+00
R_6312_6412 6312 6412 2.931970e+00
R_6412_6512 6412 6512 5.949016e+00
R_6512_6612 6512 6612 2.905175e+00
R_6612_6712 6612 6712 2.986823e+00
R_6712_6812 6712 6812 5.101437e+00
R_6812_6912 6812 6912 2.703829e+00
R_6912_7012 6912 7012 2.977572e+00
R_7012_7112 7012 7112 1.831364e+00
R_7112_7212 7112 7212 4.554623e+00
R_7212_7312 7212 7312 9.070355e+00
R_7312_7412 7312 7412 2.234921e+00
R_7412_7512 7412 7512 7.158072e+00
R_7512_7612 7512 7612 6.619039e+00
R_7612_7712 7612 7712 2.195482e+00
R_7712_7812 7712 7812 9.395687e+00
R_7812_7912 7812 7912 7.111522e+00
R_7912_8012 7912 8012 4.358084e+00
R_8012_8112 8012 8112 9.048086e+00
R_8112_8212 8112 8212 1.781301e+00
R_8212_8312 8212 8312 7.733601e+00
R_8312_8412 8312 8412 3.897715e+00
R_8412_8512 8412 8512 5.508961e+00
R_8512_8612 8512 8612 8.737196e+00
R_8612_8712 8612 8712 4.253229e+00
R_8712_8812 8712 8812 4.508541e+00
R_8812_8912 8812 8912 2.222054e-01
R_8912_9012 8912 9012 3.909064e+00
R_9012_9112 9012 9112 4.319218e+00
R_9112_9212 9112 9212 2.621516e+00
R_9212_9312 9212 9312 9.356382e+00
R_9312_9412 9312 9412 4.045580e+00
R_9412_9512 9412 9512 2.211035e+00
R_9512_9612 9512 9612 8.637923e+00
R_9612_9712 9612 9712 2.874853e+00
R_9712_9812 9712 9812 2.993773e+00
R_9812_9912 9812 9912 2.491684e+00
R_13_113 13 113 1.949121e+00
R_113_213 113 213 4.491944e+00
R_213_313 213 313 5.265357e+00
R_313_413 313 413 6.908081e-01
R_413_513 413 513 5.719018e+00
R_513_613 513 613 3.056528e+00
R_613_713 613 713 5.047074e+00
R_713_813 713 813 7.449408e+00
R_813_913 813 913 6.661946e+00
R_913_1013 913 1013 4.142903e-01
R_1013_1113 1013 1113 4.433993e-01
R_1113_1213 1113 1213 1.974689e+00
R_1213_1313 1213 1313 2.238328e+00
R_1313_1413 1313 1413 4.061214e+00
R_1413_1513 1413 1513 5.648109e+00
R_1513_1613 1513 1613 1.338848e+00
R_1613_1713 1613 1713 8.367147e+00
R_1713_1813 1713 1813 6.767497e+00
R_1813_1913 1813 1913 3.055229e+00
R_1913_2013 1913 2013 7.444010e+00
R_2013_2113 2013 2113 5.035179e+00
R_2113_2213 2113 2213 3.320048e+00
R_2213_2313 2213 2313 3.094754e+00
R_2313_2413 2313 2413 6.369359e+00
R_2413_2513 2413 2513 5.737161e+00
R_2513_2613 2513 2613 9.338846e-01
R_2613_2713 2613 2713 8.389578e+00
R_2713_2813 2713 2813 7.340636e+00
R_2813_2913 2813 2913 3.591987e+00
R_2913_3013 2913 3013 9.457349e+00
R_3013_3113 3013 3113 6.930983e+00
R_3113_3213 3113 3213 1.150180e+00
R_3213_3313 3213 3313 9.343099e-01
R_3313_3413 3313 3413 7.478699e+00
R_3413_3513 3413 3513 4.505623e-01
R_3513_3613 3513 3613 1.592897e+00
R_3613_3713 3613 3713 7.664789e+00
R_3713_3813 3713 3813 8.788287e+00
R_3813_3913 3813 3913 9.671192e+00
R_3913_4013 3913 4013 9.229861e+00
R_4013_4113 4013 4113 8.090064e+00
R_4113_4213 4113 4213 5.036270e+00
R_4213_4313 4213 4313 8.390115e+00
R_4313_4413 4313 4413 8.496734e+00
R_4413_4513 4413 4513 9.487571e+00
R_4513_4613 4513 4613 8.029421e+00
R_4613_4713 4613 4713 6.380602e+00
R_4713_4813 4713 4813 7.822710e+00
R_4813_4913 4813 4913 3.705594e+00
R_4913_5013 4913 5013 8.356901e+00
R_5013_5113 5013 5113 7.976347e+00
R_5113_5213 5113 5213 6.610321e+00
R_5213_5313 5213 5313 8.075059e+00
R_5313_5413 5313 5413 5.640555e+00
R_5413_5513 5413 5513 1.274664e-01
R_5513_5613 5513 5613 8.236158e+00
R_5613_5713 5613 5713 2.449194e+00
R_5713_5813 5713 5813 4.167708e+00
R_5813_5913 5813 5913 2.167044e+00
R_5913_6013 5913 6013 1.997032e+00
R_6013_6113 6013 6113 2.950362e+00
R_6113_6213 6113 6213 2.901435e+00
R_6213_6313 6213 6313 3.227945e+00
R_6313_6413 6313 6413 3.983345e+00
R_6413_6513 6413 6513 4.919760e+00
R_6513_6613 6513 6613 2.287934e+00
R_6613_6713 6613 6713 8.748234e+00
R_6713_6813 6713 6813 1.738285e+00
R_6813_6913 6813 6913 3.231420e+00
R_6913_7013 6913 7013 1.384092e+00
R_7013_7113 7013 7113 1.196186e+00
R_7113_7213 7113 7213 1.916597e-01
R_7213_7313 7213 7313 1.186812e+00
R_7313_7413 7313 7413 7.255340e+00
R_7413_7513 7413 7513 2.539152e+00
R_7513_7613 7513 7613 6.962016e+00
R_7613_7713 7613 7713 6.981441e+00
R_7713_7813 7713 7813 7.743620e+00
R_7813_7913 7813 7913 5.823659e+00
R_7913_8013 7913 8013 8.845591e+00
R_8013_8113 8013 8113 9.225105e-02
R_8113_8213 8113 8213 5.047946e+00
R_8213_8313 8213 8313 5.793955e-01
R_8313_8413 8313 8413 1.575543e+00
R_8413_8513 8413 8513 7.255491e+00
R_8513_8613 8513 8613 4.194974e+00
R_8613_8713 8613 8713 2.936883e+00
R_8713_8813 8713 8813 1.548121e+00
R_8813_8913 8813 8913 4.435432e-01
R_8913_9013 8913 9013 7.441511e+00
R_9013_9113 9013 9113 3.899814e+00
R_9113_9213 9113 9213 4.094021e-01
R_9213_9313 9213 9313 9.618272e+00
R_9313_9413 9313 9413 5.428581e-02
R_9413_9513 9413 9513 4.134115e+00
R_9513_9613 9513 9613 9.210982e+00
R_9613_9713 9613 9713 1.732379e+00
R_9713_9813 9713 9813 7.476614e+00
R_9813_9913 9813 9913 5.806795e+00
R_14_114 14 114 1.636747e+00
R_114_214 114 214 8.055666e-03
R_214_314 214 314 4.642797e+00
R_314_414 314 414 4.685100e+00
R_414_514 414 514 4.633563e+00
R_514_614 514 614 2.971273e+00
R_614_714 614 714 4.526821e+00
R_714_814 714 814 7.351556e+00
R_814_914 814 914 4.215349e+00
R_914_1014 914 1014 1.082811e+00
R_1014_1114 1014 1114 6.783339e+00
R_1114_1214 1114 1214 3.734446e+00
R_1214_1314 1214 1314 4.691062e+00
R_1314_1414 1314 1414 7.371033e-01
R_1414_1514 1414 1514 3.607043e+00
R_1514_1614 1514 1614 8.555739e+00
R_1614_1714 1614 1714 5.306099e+00
R_1714_1814 1714 1814 3.759328e+00
R_1814_1914 1814 1914 7.340251e+00
R_1914_2014 1914 2014 5.361038e+00
R_2014_2114 2014 2114 5.083666e+00
R_2114_2214 2114 2214 7.328669e+00
R_2214_2314 2214 2314 2.237603e+00
R_2314_2414 2314 2414 2.782417e+00
R_2414_2514 2414 2514 6.685408e+00
R_2514_2614 2514 2614 7.678892e+00
R_2614_2714 2614 2714 4.659394e+00
R_2714_2814 2714 2814 6.200447e+00
R_2814_2914 2814 2914 4.367214e+00
R_2914_3014 2914 3014 7.620474e-02
R_3014_3114 3014 3114 1.696204e-01
R_3114_3214 3114 3214 3.913602e+00
R_3214_3314 3214 3314 4.966775e+00
R_3314_3414 3314 3414 1.548014e+00
R_3414_3514 3414 3514 4.367175e+00
R_3514_3614 3514 3614 3.743268e-01
R_3614_3714 3614 3714 1.311165e+00
R_3714_3814 3714 3814 9.755451e+00
R_3814_3914 3814 3914 7.919034e+00
R_3914_4014 3914 4014 9.222124e-01
R_4014_4114 4014 4114 4.894907e+00
R_4114_4214 4114 4214 7.552024e+00
R_4214_4314 4214 4314 2.537716e+00
R_4314_4414 4314 4414 5.671724e+00
R_4414_4514 4414 4514 3.067352e+00
R_4514_4614 4514 4614 5.936480e+00
R_4614_4714 4614 4714 2.007349e+00
R_4714_4814 4714 4814 8.892297e+00
R_4814_4914 4814 4914 2.437690e+00
R_4914_5014 4914 5014 1.691587e+00
R_5014_5114 5014 5114 3.276199e+00
R_5114_5214 5114 5214 8.283669e+00
R_5214_5314 5214 5314 2.692059e+00
R_5314_5414 5314 5414 7.836824e+00
R_5414_5514 5414 5514 2.361172e+00
R_5514_5614 5514 5614 6.859189e+00
R_5614_5714 5614 5714 6.437543e+00
R_5714_5814 5714 5814 9.182018e+00
R_5814_5914 5814 5914 1.933018e+00
R_5914_6014 5914 6014 1.132122e+00
R_6014_6114 6014 6114 8.045915e-01
R_6114_6214 6114 6214 4.531784e+00
R_6214_6314 6214 6314 7.352320e+00
R_6314_6414 6314 6414 5.442849e+00
R_6414_6514 6414 6514 4.819453e+00
R_6514_6614 6514 6614 1.765872e-01
R_6614_6714 6614 6714 3.271057e+00
R_6714_6814 6714 6814 6.672645e+00
R_6814_6914 6814 6914 3.368374e+00
R_6914_7014 6914 7014 3.828953e+00
R_7014_7114 7014 7114 9.012784e+00
R_7114_7214 7114 7214 2.323390e+00
R_7214_7314 7214 7314 9.910450e+00
R_7314_7414 7314 7414 8.583662e+00
R_7414_7514 7414 7514 4.704522e-01
R_7514_7614 7514 7614 9.559663e+00
R_7614_7714 7614 7714 1.066285e+00
R_7714_7814 7714 7814 3.190610e+00
R_7814_7914 7814 7914 7.322902e+00
R_7914_8014 7914 8014 2.167200e+00
R_8014_8114 8014 8114 4.422216e+00
R_8114_8214 8114 8214 9.713915e+00
R_8214_8314 8214 8314 5.280841e+00
R_8314_8414 8314 8414 9.844457e+00
R_8414_8514 8414 8514 1.893614e+00
R_8514_8614 8514 8614 3.892725e+00
R_8614_8714 8614 8714 8.811803e+00
R_8714_8814 8714 8814 3.732670e+00
R_8814_8914 8814 8914 3.411909e+00
R_8914_9014 8914 9014 8.726769e+00
R_9014_9114 9014 9114 7.416091e+00
R_9114_9214 9114 9214 2.610475e+00
R_9214_9314 9214 9314 7.998749e+00
R_9314_9414 9314 9414 4.607501e+00
R_9414_9514 9414 9514 4.150831e-02
R_9514_9614 9514 9614 5.758191e+00
R_9614_9714 9614 9714 9.738557e+00
R_9714_9814 9714 9814 8.397859e+00
R_9814_9914 9814 9914 3.946913e+00
R_15_115 15 115 3.633582e+00
R_115_215 115 215 3.184342e+00
R_215_315 215 315 9.169506e+00
R_315_415 315 415 5.148633e+00
R_415_515 415 515 5.197250e+00
R_515_615 515 615 2.467159e+00
R_615_715 615 715 6.326589e+00
R_715_815 715 815 4.653889e+00
R_815_915 815 915 5.219966e+00
R_915_1015 915 1015 8.137910e+00
R_1015_1115 1015 1115 4.175471e+00
R_1115_1215 1115 1215 4.018136e+00
R_1215_1315 1215 1315 6.729664e-01
R_1315_1415 1315 1415 2.565022e+00
R_1415_1515 1415 1515 9.827291e+00
R_1515_1615 1515 1615 5.236956e+00
R_1615_1715 1615 1715 4.719719e+00
R_1715_1815 1715 1815 6.037733e+00
R_1815_1915 1815 1915 9.696976e+00
R_1915_2015 1915 2015 7.570950e+00
R_2015_2115 2015 2115 7.625098e+00
R_2115_2215 2115 2215 2.658252e+00
R_2215_2315 2215 2315 7.739503e+00
R_2315_2415 2315 2415 8.483202e+00
R_2415_2515 2415 2515 4.565362e+00
R_2515_2615 2515 2615 4.325308e+00
R_2615_2715 2615 2715 4.258602e+00
R_2715_2815 2715 2815 5.294768e+00
R_2815_2915 2815 2915 9.923533e+00
R_2915_3015 2915 3015 3.009982e+00
R_3015_3115 3015 3115 6.648645e+00
R_3115_3215 3115 3215 5.016848e+00
R_3215_3315 3215 3315 7.005122e+00
R_3315_3415 3315 3415 1.478570e+00
R_3415_3515 3415 3515 4.306854e+00
R_3515_3615 3515 3615 3.969860e+00
R_3615_3715 3615 3715 2.837713e+00
R_3715_3815 3715 3815 1.424211e+00
R_3815_3915 3815 3915 1.137624e+00
R_3915_4015 3915 4015 9.525412e-03
R_4015_4115 4015 4115 4.474805e+00
R_4115_4215 4115 4215 9.906587e+00
R_4215_4315 4215 4315 2.210547e+00
R_4315_4415 4315 4415 7.329332e+00
R_4415_4515 4415 4515 5.343446e+00
R_4515_4615 4515 4615 9.131353e+00
R_4615_4715 4615 4715 7.558471e+00
R_4715_4815 4715 4815 7.363901e+00
R_4815_4915 4815 4915 3.038721e-01
R_4915_5015 4915 5015 3.107185e+00
R_5015_5115 5015 5115 2.427186e-01
R_5115_5215 5115 5215 5.009806e-01
R_5215_5315 5215 5315 1.105570e+00
R_5315_5415 5315 5415 4.887736e+00
R_5415_5515 5415 5515 8.260732e+00
R_5515_5615 5515 5615 2.074027e+00
R_5615_5715 5615 5715 1.496840e+00
R_5715_5815 5715 5815 8.388608e+00
R_5815_5915 5815 5915 1.480266e-01
R_5915_6015 5915 6015 6.586281e+00
R_6015_6115 6015 6115 3.304852e+00
R_6115_6215 6115 6215 9.700138e+00
R_6215_6315 6215 6315 3.759122e+00
R_6315_6415 6315 6415 2.159132e+00
R_6415_6515 6415 6515 2.683226e+00
R_6515_6615 6515 6615 5.406785e+00
R_6615_6715 6615 6715 2.548024e+00
R_6715_6815 6715 6815 7.898367e+00
R_6815_6915 6815 6915 3.695065e+00
R_6915_7015 6915 7015 4.046560e+00
R_7015_7115 7015 7115 1.292274e+00
R_7115_7215 7115 7215 5.862790e+00
R_7215_7315 7215 7315 9.176366e+00
R_7315_7415 7315 7415 7.129453e-01
R_7415_7515 7415 7515 4.613048e+00
R_7515_7615 7515 7615 9.860165e+00
R_7615_7715 7615 7715 6.353247e+00
R_7715_7815 7715 7815 5.431815e+00
R_7815_7915 7815 7915 2.299575e+00
R_7915_8015 7915 8015 1.425931e+00
R_8015_8115 8015 8115 1.947120e+00
R_8115_8215 8115 8215 5.213623e+00
R_8215_8315 8215 8315 1.799234e+00
R_8315_8415 8315 8415 6.955215e+00
R_8415_8515 8415 8515 3.850400e+00
R_8515_8615 8515 8615 2.692107e+00
R_8615_8715 8615 8715 8.414032e+00
R_8715_8815 8715 8815 9.838213e+00
R_8815_8915 8815 8915 7.543397e+00
R_8915_9015 8915 9015 9.706091e+00
R_9015_9115 9015 9115 4.822047e+00
R_9115_9215 9115 9215 7.329647e+00
R_9215_9315 9215 9315 9.665156e-01
R_9315_9415 9315 9415 1.166884e+00
R_9415_9515 9415 9515 2.954425e+00
R_9515_9615 9515 9615 4.812435e+00
R_9615_9715 9615 9715 8.313383e+00
R_9715_9815 9715 9815 1.572001e+00
R_9815_9915 9815 9915 8.574471e+00
R_16_116 16 116 4.415588e+00
R_116_216 116 216 4.424326e-02
R_216_316 216 316 3.368980e+00
R_316_416 316 416 9.452214e+00
R_416_516 416 516 6.265172e+00
R_516_616 516 616 2.257540e+00
R_616_716 616 716 8.494260e+00
R_716_816 716 816 7.964256e+00
R_816_916 816 916 5.179376e+00
R_916_1016 916 1016 8.390712e+00
R_1016_1116 1016 1116 6.603196e+00
R_1116_1216 1116 1216 8.220297e+00
R_1216_1316 1216 1316 9.089181e+00
R_1316_1416 1316 1416 4.147484e+00
R_1416_1516 1416 1516 1.586873e+00
R_1516_1616 1516 1616 5.336967e+00
R_1616_1716 1616 1716 7.198451e+00
R_1716_1816 1716 1816 5.315056e-01
R_1816_1916 1816 1916 1.058690e+00
R_1916_2016 1916 2016 6.929686e+00
R_2016_2116 2016 2116 8.770665e+00
R_2116_2216 2116 2216 3.933868e+00
R_2216_2316 2216 2316 7.202793e+00
R_2316_2416 2316 2416 3.154792e+00
R_2416_2516 2416 2516 4.306930e+00
R_2516_2616 2516 2616 6.146870e+00
R_2616_2716 2616 2716 7.438430e+00
R_2716_2816 2716 2816 2.863722e+00
R_2816_2916 2816 2916 1.696567e+00
R_2916_3016 2916 3016 2.218268e+00
R_3016_3116 3016 3116 9.988201e+00
R_3116_3216 3116 3216 3.038576e+00
R_3216_3316 3216 3316 3.859688e+00
R_3316_3416 3316 3416 9.949980e+00
R_3416_3516 3416 3516 7.368336e+00
R_3516_3616 3516 3616 5.522535e+00
R_3616_3716 3616 3716 8.440757e+00
R_3716_3816 3716 3816 4.994200e+00
R_3816_3916 3816 3916 5.143150e+00
R_3916_4016 3916 4016 2.480869e+00
R_4016_4116 4016 4116 3.364480e+00
R_4116_4216 4116 4216 6.383716e+00
R_4216_4316 4216 4316 2.787200e+00
R_4316_4416 4316 4416 5.607222e-01
R_4416_4516 4416 4516 6.574999e+00
R_4516_4616 4516 4616 1.180926e+00
R_4616_4716 4616 4716 1.953170e-01
R_4716_4816 4716 4816 7.826845e+00
R_4816_4916 4816 4916 7.950988e+00
R_4916_5016 4916 5016 7.114479e+00
R_5016_5116 5016 5116 3.337437e-02
R_5116_5216 5116 5216 9.200077e+00
R_5216_5316 5216 5316 3.021287e-01
R_5316_5416 5316 5416 1.361812e+00
R_5416_5516 5416 5516 8.503946e+00
R_5516_5616 5516 5616 2.092532e-01
R_5616_5716 5616 5716 8.082164e+00
R_5716_5816 5716 5816 4.122895e-01
R_5816_5916 5816 5916 1.978049e+00
R_5916_6016 5916 6016 6.339443e+00
R_6016_6116 6016 6116 6.703069e+00
R_6116_6216 6116 6216 4.181953e+00
R_6216_6316 6216 6316 3.546922e+00
R_6316_6416 6316 6416 9.727677e+00
R_6416_6516 6416 6516 4.619861e+00
R_6516_6616 6516 6616 4.248096e-01
R_6616_6716 6616 6716 3.067227e+00
R_6716_6816 6716 6816 6.559211e+00
R_6816_6916 6816 6916 3.245804e+00
R_6916_7016 6916 7016 6.673956e+00
R_7016_7116 7016 7116 9.790948e+00
R_7116_7216 7116 7216 9.283409e+00
R_7216_7316 7216 7316 2.942702e+00
R_7316_7416 7316 7416 8.990542e+00
R_7416_7516 7416 7516 8.806431e-01
R_7516_7616 7516 7616 7.375760e+00
R_7616_7716 7616 7716 1.672806e+00
R_7716_7816 7716 7816 3.099321e+00
R_7816_7916 7816 7916 1.691871e+00
R_7916_8016 7916 8016 1.977737e+00
R_8016_8116 8016 8116 3.024192e+00
R_8116_8216 8116 8216 1.224376e-02
R_8216_8316 8216 8316 1.730352e+00
R_8316_8416 8316 8416 1.065389e+00
R_8416_8516 8416 8516 7.947160e+00
R_8516_8616 8516 8616 8.578878e-01
R_8616_8716 8616 8716 6.518816e+00
R_8716_8816 8716 8816 8.096493e+00
R_8816_8916 8816 8916 8.106607e+00
R_8916_9016 8916 9016 9.403492e+00
R_9016_9116 9016 9116 9.312795e+00
R_9116_9216 9116 9216 9.507692e+00
R_9216_9316 9216 9316 2.005473e+00
R_9316_9416 9316 9416 1.575542e+00
R_9416_9516 9416 9516 4.015342e+00
R_9516_9616 9516 9616 2.380133e+00
R_9616_9716 9616 9716 5.605008e+00
R_9716_9816 9716 9816 4.564902e+00
R_9816_9916 9816 9916 6.925088e+00
R_17_117 17 117 3.886435e+00
R_117_217 117 217 1.619868e+00
R_217_317 217 317 4.932013e+00
R_317_417 317 417 7.050238e+00
R_417_517 417 517 1.564781e-01
R_517_617 517 617 5.655010e+00
R_617_717 617 717 4.927006e+00
R_717_817 717 817 6.774347e+00
R_817_917 817 917 7.122437e+00
R_917_1017 917 1017 1.433666e+00
R_1017_1117 1017 1117 5.057738e+00
R_1117_1217 1117 1217 7.231744e+00
R_1217_1317 1217 1317 4.325040e+00
R_1317_1417 1317 1417 9.097204e+00
R_1417_1517 1417 1517 3.615302e+00
R_1517_1617 1517 1617 2.309022e-01
R_1617_1717 1617 1717 2.488456e+00
R_1717_1817 1717 1817 2.506481e+00
R_1817_1917 1817 1917 9.173384e+00
R_1917_2017 1917 2017 8.885396e+00
R_2017_2117 2017 2117 5.828971e+00
R_2117_2217 2117 2217 8.138272e+00
R_2217_2317 2217 2317 3.148069e+00
R_2317_2417 2317 2417 8.095482e+00
R_2417_2517 2417 2517 5.865381e+00
R_2517_2617 2517 2617 9.107166e-01
R_2617_2717 2617 2717 1.038275e+00
R_2717_2817 2717 2817 1.427991e+00
R_2817_2917 2817 2917 8.309288e+00
R_2917_3017 2917 3017 4.117585e+00
R_3017_3117 3017 3117 1.601004e+00
R_3117_3217 3117 3217 4.676031e+00
R_3217_3317 3217 3317 7.236056e-01
R_3317_3417 3317 3417 4.152153e+00
R_3417_3517 3417 3517 9.038181e+00
R_3517_3617 3517 3617 4.118329e+00
R_3617_3717 3617 3717 3.013120e+00
R_3717_3817 3717 3817 8.096866e+00
R_3817_3917 3817 3917 1.766812e+00
R_3917_4017 3917 4017 7.737161e+00
R_4017_4117 4017 4117 8.297156e+00
R_4117_4217 4117 4217 6.380710e+00
R_4217_4317 4217 4317 6.288419e+00
R_4317_4417 4317 4417 6.045601e+00
R_4417_4517 4417 4517 4.525272e+00
R_4517_4617 4517 4617 4.303766e+00
R_4617_4717 4617 4717 2.901152e+00
R_4717_4817 4717 4817 5.297793e+00
R_4817_4917 4817 4917 3.589949e-01
R_4917_5017 4917 5017 9.118385e+00
R_5017_5117 5017 5117 3.166129e-01
R_5117_5217 5117 5217 9.669175e+00
R_5217_5317 5217 5317 5.871736e+00
R_5317_5417 5317 5417 5.885723e+00
R_5417_5517 5417 5517 6.444736e+00
R_5517_5617 5517 5617 6.870331e+00
R_5617_5717 5617 5717 1.700318e+00
R_5717_5817 5717 5817 6.661141e+00
R_5817_5917 5817 5917 9.878206e+00
R_5917_6017 5917 6017 6.562038e+00
R_6017_6117 6017 6117 7.167111e+00
R_6117_6217 6117 6217 1.285906e+00
R_6217_6317 6217 6317 7.923961e+00
R_6317_6417 6317 6417 6.714901e+00
R_6417_6517 6417 6517 5.661848e+00
R_6517_6617 6517 6617 5.287699e+00
R_6617_6717 6617 6717 6.613788e+00
R_6717_6817 6717 6817 2.089706e+00
R_6817_6917 6817 6917 4.087232e+00
R_6917_7017 6917 7017 8.261193e+00
R_7017_7117 7017 7117 4.526924e-01
R_7117_7217 7117 7217 6.248663e+00
R_7217_7317 7217 7317 6.403719e-01
R_7317_7417 7317 7417 7.423773e-01
R_7417_7517 7417 7517 6.909880e+00
R_7517_7617 7517 7617 4.836839e+00
R_7617_7717 7617 7717 4.591856e+00
R_7717_7817 7717 7817 2.178750e-01
R_7817_7917 7817 7917 3.721548e+00
R_7917_8017 7917 8017 7.616810e+00
R_8017_8117 8017 8117 7.241246e+00
R_8117_8217 8117 8217 3.227748e+00
R_8217_8317 8217 8317 9.368266e+00
R_8317_8417 8317 8417 5.919960e+00
R_8417_8517 8417 8517 3.546389e+00
R_8517_8617 8517 8617 7.101361e+00
R_8617_8717 8617 8717 8.712534e+00
R_8717_8817 8717 8817 2.889501e+00
R_8817_8917 8817 8917 4.746555e+00
R_8917_9017 8917 9017 4.529053e+00
R_9017_9117 9017 9117 5.347717e+00
R_9117_9217 9117 9217 5.907252e-01
R_9217_9317 9217 9317 4.370491e+00
R_9317_9417 9317 9417 6.212963e-01
R_9417_9517 9417 9517 9.370418e+00
R_9517_9617 9517 9617 1.736066e+00
R_9617_9717 9617 9717 5.475503e+00
R_9717_9817 9717 9817 2.199012e+00
R_9817_9917 9817 9917 4.874940e+00
R_18_118 18 118 3.343261e-01
R_118_218 118 218 1.644562e+00
R_218_318 218 318 3.564484e+00
R_318_418 318 418 2.575806e+00
R_418_518 418 518 6.563307e+00
R_518_618 518 618 7.576061e+00
R_618_718 618 718 6.644361e+00
R_718_818 718 818 2.840522e+00
R_818_918 818 918 5.243822e+00
R_918_1018 918 1018 6.113618e-01
R_1018_1118 1018 1118 8.618171e+00
R_1118_1218 1118 1218 1.563046e+00
R_1218_1318 1218 1318 8.661885e+00
R_1318_1418 1318 1418 3.448222e+00
R_1418_1518 1418 1518 9.912656e+00
R_1518_1618 1518 1618 6.778282e+00
R_1618_1718 1618 1718 5.418846e+00
R_1718_1818 1718 1818 5.963496e+00
R_1818_1918 1818 1918 7.646560e+00
R_1918_2018 1918 2018 7.358428e+00
R_2018_2118 2018 2118 6.473343e+00
R_2118_2218 2118 2218 8.510848e+00
R_2218_2318 2218 2318 8.591115e+00
R_2318_2418 2318 2418 9.143734e+00
R_2418_2518 2418 2518 9.125926e+00
R_2518_2618 2518 2618 7.794621e+00
R_2618_2718 2618 2718 8.276139e-01
R_2718_2818 2718 2818 5.509930e+00
R_2818_2918 2818 2918 9.393751e+00
R_2918_3018 2918 3018 8.670828e+00
R_3018_3118 3018 3118 2.382159e+00
R_3118_3218 3118 3218 5.890054e+00
R_3218_3318 3218 3318 5.716819e+00
R_3318_3418 3318 3418 6.330132e+00
R_3418_3518 3418 3518 6.606245e+00
R_3518_3618 3518 3618 2.455801e+00
R_3618_3718 3618 3718 6.620998e-02
R_3718_3818 3718 3818 1.084657e+00
R_3818_3918 3818 3918 7.752276e+00
R_3918_4018 3918 4018 5.701149e+00
R_4018_4118 4018 4118 1.293714e+00
R_4118_4218 4118 4218 3.196784e+00
R_4218_4318 4218 4318 6.658583e+00
R_4318_4418 4318 4418 7.705765e+00
R_4418_4518 4418 4518 6.492959e-01
R_4518_4618 4518 4618 9.298239e+00
R_4618_4718 4618 4718 4.784664e+00
R_4718_4818 4718 4818 1.364851e+00
R_4818_4918 4818 4918 6.600620e-01
R_4918_5018 4918 5018 8.741845e+00
R_5018_5118 5018 5118 9.980881e+00
R_5118_5218 5118 5218 1.281124e+00
R_5218_5318 5218 5318 9.285748e+00
R_5318_5418 5318 5418 5.881036e+00
R_5418_5518 5418 5518 8.343226e-01
R_5518_5618 5518 5618 8.616237e-01
R_5618_5718 5618 5718 4.660163e-01
R_5718_5818 5718 5818 5.934116e+00
R_5818_5918 5818 5918 5.710090e+00
R_5918_6018 5918 6018 7.992336e+00
R_6018_6118 6018 6118 8.111441e+00
R_6118_6218 6118 6218 4.607075e+00
R_6218_6318 6218 6318 7.440980e+00
R_6318_6418 6318 6418 1.297538e+00
R_6418_6518 6418 6518 6.094901e+00
R_6518_6618 6518 6618 5.875957e+00
R_6618_6718 6618 6718 5.500514e-01
R_6718_6818 6718 6818 8.258165e+00
R_6818_6918 6818 6918 8.681062e+00
R_6918_7018 6918 7018 7.460084e+00
R_7018_7118 7018 7118 5.506663e+00
R_7118_7218 7118 7218 9.281259e+00
R_7218_7318 7218 7318 5.148460e+00
R_7318_7418 7318 7418 5.806936e+00
R_7418_7518 7418 7518 1.699346e+00
R_7518_7618 7518 7618 2.447993e+00
R_7618_7718 7618 7718 3.511861e+00
R_7718_7818 7718 7818 2.258551e+00
R_7818_7918 7818 7918 6.511747e+00
R_7918_8018 7918 8018 1.695992e+00
R_8018_8118 8018 8118 7.606302e+00
R_8118_8218 8118 8218 9.945243e+00
R_8218_8318 8218 8318 2.764206e+00
R_8318_8418 8318 8418 8.108155e+00
R_8418_8518 8418 8518 6.598894e-01
R_8518_8618 8518 8618 4.732404e+00
R_8618_8718 8618 8718 7.409418e+00
R_8718_8818 8718 8818 2.537703e+00
R_8818_8918 8818 8918 9.953933e+00
R_8918_9018 8918 9018 3.528748e-02
R_9018_9118 9018 9118 9.790787e+00
R_9118_9218 9118 9218 8.522564e+00
R_9218_9318 9218 9318 4.772310e+00
R_9318_9418 9318 9418 4.178503e+00
R_9418_9518 9418 9518 6.990879e+00
R_9518_9618 9518 9618 8.944414e+00
R_9618_9718 9618 9718 1.010665e+00
R_9718_9818 9718 9818 2.186444e+00
R_9818_9918 9818 9918 8.330967e+00
R_19_119 19 119 8.745067e+00
R_119_219 119 219 7.963733e+00
R_219_319 219 319 9.302011e+00
R_319_419 319 419 2.186460e+00
R_419_519 419 519 2.442092e+00
R_519_619 519 619 5.043470e+00
R_619_719 619 719 1.208188e+00
R_719_819 719 819 4.345941e+00
R_819_919 819 919 4.124075e+00
R_919_1019 919 1019 3.949639e+00
R_1019_1119 1019 1119 3.893114e+00
R_1119_1219 1119 1219 6.262006e+00
R_1219_1319 1219 1319 9.312718e+00
R_1319_1419 1319 1419 5.002220e+00
R_1419_1519 1419 1519 3.863038e+00
R_1519_1619 1519 1619 5.459741e+00
R_1619_1719 1619 1719 2.339843e+00
R_1719_1819 1719 1819 9.654875e+00
R_1819_1919 1819 1919 1.247330e+00
R_1919_2019 1919 2019 6.193954e-01
R_2019_2119 2019 2119 4.133744e+00
R_2119_2219 2119 2219 6.214347e+00
R_2219_2319 2219 2319 2.163267e+00
R_2319_2419 2319 2419 4.263762e+00
R_2419_2519 2419 2519 6.928575e+00
R_2519_2619 2519 2619 9.393329e+00
R_2619_2719 2619 2719 6.915029e+00
R_2719_2819 2719 2819 6.767585e+00
R_2819_2919 2819 2919 6.709900e+00
R_2919_3019 2919 3019 6.354849e+00
R_3019_3119 3019 3119 7.385194e+00
R_3119_3219 3119 3219 2.959170e+00
R_3219_3319 3219 3319 9.027082e+00
R_3319_3419 3319 3419 1.276272e+00
R_3419_3519 3419 3519 1.067057e+00
R_3519_3619 3519 3619 8.638646e+00
R_3619_3719 3619 3719 5.734640e+00
R_3719_3819 3719 3819 5.309027e+00
R_3819_3919 3819 3919 3.938671e+00
R_3919_4019 3919 4019 1.375265e+00
R_4019_4119 4019 4119 3.538411e+00
R_4119_4219 4119 4219 4.156192e+00
R_4219_4319 4219 4319 6.746948e+00
R_4319_4419 4319 4419 4.501212e+00
R_4419_4519 4419 4519 1.642983e+00
R_4519_4619 4519 4619 8.010760e+00
R_4619_4719 4619 4719 6.245396e+00
R_4719_4819 4719 4819 9.523433e+00
R_4819_4919 4819 4919 2.516308e+00
R_4919_5019 4919 5019 2.756838e+00
R_5019_5119 5019 5119 6.379959e+00
R_5119_5219 5119 5219 7.538169e+00
R_5219_5319 5219 5319 9.234323e+00
R_5319_5419 5319 5419 4.979283e+00
R_5419_5519 5419 5519 5.935603e+00
R_5519_5619 5519 5619 6.509278e+00
R_5619_5719 5619 5719 8.969447e+00
R_5719_5819 5719 5819 4.068369e+00
R_5819_5919 5819 5919 7.716577e-01
R_5919_6019 5919 6019 3.998944e+00
R_6019_6119 6019 6119 3.653642e-03
R_6119_6219 6119 6219 4.320317e+00
R_6219_6319 6219 6319 9.223357e+00
R_6319_6419 6319 6419 2.159813e+00
R_6419_6519 6419 6519 2.751865e-01
R_6519_6619 6519 6619 8.139006e+00
R_6619_6719 6619 6719 1.885347e+00
R_6719_6819 6719 6819 9.723980e+00
R_6819_6919 6819 6919 8.145203e+00
R_6919_7019 6919 7019 8.019021e-01
R_7019_7119 7019 7119 7.482321e+00
R_7119_7219 7119 7219 6.110200e+00
R_7219_7319 7219 7319 4.379587e+00
R_7319_7419 7319 7419 8.209854e+00
R_7419_7519 7419 7519 7.609963e+00
R_7519_7619 7519 7619 9.065993e+00
R_7619_7719 7619 7719 7.111999e+00
R_7719_7819 7719 7819 9.557939e+00
R_7819_7919 7819 7919 3.172329e+00
R_7919_8019 7919 8019 4.330867e+00
R_8019_8119 8019 8119 2.833989e+00
R_8119_8219 8119 8219 8.259913e+00
R_8219_8319 8219 8319 4.846835e+00
R_8319_8419 8319 8419 3.171549e+00
R_8419_8519 8419 8519 3.624775e+00
R_8519_8619 8519 8619 8.485660e+00
R_8619_8719 8619 8719 9.994490e+00
R_8719_8819 8719 8819 4.217269e+00
R_8819_8919 8819 8919 5.369185e-01
R_8919_9019 8919 9019 4.539075e+00
R_9019_9119 9019 9119 2.859567e+00
R_9119_9219 9119 9219 4.555733e+00
R_9219_9319 9219 9319 3.393693e+00
R_9319_9419 9319 9419 7.588682e+00
R_9419_9519 9419 9519 5.670386e+00
R_9519_9619 9519 9619 4.129102e+00
R_9619_9719 9619 9719 3.601998e+00
R_9719_9819 9719 9819 8.359099e+00
R_9819_9919 9819 9919 3.960054e+00
R_20_120 20 120 7.077207e+00
R_120_220 120 220 2.061234e+00
R_220_320 220 320 3.389406e+00
R_320_420 320 420 3.295682e+00
R_420_520 420 520 6.854234e+00
R_520_620 520 620 5.479666e+00
R_620_720 620 720 5.451236e+00
R_720_820 720 820 9.574031e+00
R_820_920 820 920 8.629152e+00
R_920_1020 920 1020 1.275209e+00
R_1020_1120 1020 1120 4.933524e-01
R_1120_1220 1120 1220 1.770062e+00
R_1220_1320 1220 1320 5.811045e+00
R_1320_1420 1320 1420 8.620422e+00
R_1420_1520 1420 1520 8.311137e+00
R_1520_1620 1520 1620 2.742930e+00
R_1620_1720 1620 1720 7.272219e+00
R_1720_1820 1720 1820 1.967432e+00
R_1820_1920 1820 1920 4.997896e-01
R_1920_2020 1920 2020 9.832732e+00
R_2020_2120 2020 2120 7.661472e+00
R_2120_2220 2120 2220 3.503515e+00
R_2220_2320 2220 2320 7.279138e+00
R_2320_2420 2320 2420 4.456572e+00
R_2420_2520 2420 2520 5.964871e+00
R_2520_2620 2520 2620 3.713102e+00
R_2620_2720 2620 2720 5.253999e+00
R_2720_2820 2720 2820 4.902198e+00
R_2820_2920 2820 2920 2.000907e+00
R_2920_3020 2920 3020 9.295594e+00
R_3020_3120 3020 3120 3.259234e+00
R_3120_3220 3120 3220 2.855783e+00
R_3220_3320 3220 3320 9.488252e+00
R_3320_3420 3320 3420 4.562234e+00
R_3420_3520 3420 3520 1.957159e+00
R_3520_3620 3520 3620 5.572597e+00
R_3620_3720 3620 3720 7.212807e+00
R_3720_3820 3720 3820 1.742273e+00
R_3820_3920 3820 3920 4.626550e+00
R_3920_4020 3920 4020 6.456233e-01
R_4020_4120 4020 4120 9.356947e+00
R_4120_4220 4120 4220 9.146004e+00
R_4220_4320 4220 4320 1.274145e+00
R_4320_4420 4320 4420 7.074937e-01
R_4420_4520 4420 4520 3.437757e-01
R_4520_4620 4520 4620 1.369099e+00
R_4620_4720 4620 4720 6.580359e+00
R_4720_4820 4720 4820 8.636164e-01
R_4820_4920 4820 4920 5.958432e+00
R_4920_5020 4920 5020 5.543120e+00
R_5020_5120 5020 5120 2.085735e+00
R_5120_5220 5120 5220 6.959416e+00
R_5220_5320 5220 5320 1.460308e+00
R_5320_5420 5320 5420 2.353824e+00
R_5420_5520 5420 5520 7.943203e+00
R_5520_5620 5520 5620 3.753839e+00
R_5620_5720 5620 5720 4.431345e+00
R_5720_5820 5720 5820 3.862785e+00
R_5820_5920 5820 5920 5.990774e+00
R_5920_6020 5920 6020 9.177818e+00
R_6020_6120 6020 6120 4.456624e-01
R_6120_6220 6120 6220 4.168550e+00
R_6220_6320 6220 6320 9.180591e+00
R_6320_6420 6320 6420 6.168114e+00
R_6420_6520 6420 6520 9.343599e+00
R_6520_6620 6520 6620 4.622840e-01
R_6620_6720 6620 6720 6.553427e+00
R_6720_6820 6720 6820 1.985198e+00
R_6820_6920 6820 6920 2.170875e+00
R_6920_7020 6920 7020 8.911482e+00
R_7020_7120 7020 7120 5.183675e+00
R_7120_7220 7120 7220 8.306919e+00
R_7220_7320 7220 7320 7.764478e+00
R_7320_7420 7320 7420 3.667478e+00
R_7420_7520 7420 7520 9.786210e+00
R_7520_7620 7520 7620 9.942465e+00
R_7620_7720 7620 7720 8.743934e+00
R_7720_7820 7720 7820 4.732049e+00
R_7820_7920 7820 7920 5.422812e+00
R_7920_8020 7920 8020 8.294033e+00
R_8020_8120 8020 8120 6.159853e+00
R_8120_8220 8120 8220 5.055221e+00
R_8220_8320 8220 8320 7.501584e+00
R_8320_8420 8320 8420 9.430196e+00
R_8420_8520 8420 8520 4.306707e-01
R_8520_8620 8520 8620 7.569718e+00
R_8620_8720 8620 8720 5.169227e+00
R_8720_8820 8720 8820 5.610652e+00
R_8820_8920 8820 8920 2.100097e+00
R_8920_9020 8920 9020 7.937163e-01
R_9020_9120 9020 9120 7.565615e+00
R_9120_9220 9120 9220 7.895767e+00
R_9220_9320 9220 9320 9.762418e+00
R_9320_9420 9320 9420 4.439942e-01
R_9420_9520 9420 9520 8.252702e+00
R_9520_9620 9520 9620 1.834262e+00
R_9620_9720 9620 9720 5.425227e+00
R_9720_9820 9720 9820 9.045076e+00
R_9820_9920 9820 9920 7.152050e+00
R_21_121 21 121 6.207193e+00
R_121_221 121 221 6.541453e+00
R_221_321 221 321 7.119801e-02
R_321_421 321 421 1.858841e+00
R_421_521 421 521 4.766734e+00
R_521_621 521 621 9.404388e+00
R_621_721 621 721 3.697104e+00
R_721_821 721 821 3.882845e+00
R_821_921 821 921 7.065729e+00
R_921_1021 921 1021 9.267358e+00
R_1021_1121 1021 1121 7.062325e+00
R_1121_1221 1121 1221 1.628129e+00
R_1221_1321 1221 1321 8.645525e+00
R_1321_1421 1321 1421 3.458214e+00
R_1421_1521 1421 1521 8.128662e+00
R_1521_1621 1521 1621 6.936027e+00
R_1621_1721 1621 1721 8.961307e+00
R_1721_1821 1721 1821 8.230008e+00
R_1821_1921 1821 1921 5.699285e+00
R_1921_2021 1921 2021 9.725237e+00
R_2021_2121 2021 2121 2.255779e-01
R_2121_2221 2121 2221 6.065237e+00
R_2221_2321 2221 2321 5.770885e+00
R_2321_2421 2321 2421 4.642032e+00
R_2421_2521 2421 2521 8.954221e+00
R_2521_2621 2521 2621 8.354489e+00
R_2621_2721 2621 2721 3.929538e+00
R_2721_2821 2721 2821 8.057402e+00
R_2821_2921 2821 2921 1.380916e+00
R_2921_3021 2921 3021 6.401937e+00
R_3021_3121 3021 3121 1.799827e+00
R_3121_3221 3121 3221 8.073600e-01
R_3221_3321 3221 3321 6.872171e-01
R_3321_3421 3321 3421 6.996556e+00
R_3421_3521 3421 3521 2.864144e+00
R_3521_3621 3521 3621 4.917615e-01
R_3621_3721 3621 3721 9.260569e+00
R_3721_3821 3721 3821 6.427474e+00
R_3821_3921 3821 3921 3.236030e+00
R_3921_4021 3921 4021 2.602119e+00
R_4021_4121 4021 4121 8.832881e+00
R_4121_4221 4121 4221 3.441442e-01
R_4221_4321 4221 4321 6.554123e+00
R_4321_4421 4321 4421 7.556262e+00
R_4421_4521 4421 4521 6.739515e+00
R_4521_4621 4521 4621 9.395951e+00
R_4621_4721 4621 4721 9.587256e+00
R_4721_4821 4721 4821 5.453409e+00
R_4821_4921 4821 4921 5.116981e-01
R_4921_5021 4921 5021 9.649769e+00
R_5021_5121 5021 5121 4.973546e+00
R_5121_5221 5121 5221 1.634631e-01
R_5221_5321 5221 5321 4.549270e+00
R_5321_5421 5321 5421 1.205298e+00
R_5421_5521 5421 5521 2.249450e+00
R_5521_5621 5521 5621 2.161786e+00
R_5621_5721 5621 5721 2.970892e+00
R_5721_5821 5721 5821 2.353116e+00
R_5821_5921 5821 5921 7.962798e+00
R_5921_6021 5921 6021 4.614301e+00
R_6021_6121 6021 6121 7.741792e+00
R_6121_6221 6121 6221 3.145938e+00
R_6221_6321 6221 6321 8.925425e-01
R_6321_6421 6321 6421 3.328213e+00
R_6421_6521 6421 6521 3.286729e+00
R_6521_6621 6521 6621 4.701191e+00
R_6621_6721 6621 6721 7.384739e+00
R_6721_6821 6721 6821 2.832347e+00
R_6821_6921 6821 6921 8.018804e+00
R_6921_7021 6921 7021 8.448354e+00
R_7021_7121 7021 7121 4.354955e+00
R_7121_7221 7121 7221 7.577101e+00
R_7221_7321 7221 7321 2.396395e+00
R_7321_7421 7321 7421 1.802606e-01
R_7421_7521 7421 7521 9.588864e+00
R_7521_7621 7521 7621 9.268995e+00
R_7621_7721 7621 7721 5.048229e+00
R_7721_7821 7721 7821 5.018886e-01
R_7821_7921 7821 7921 6.749728e+00
R_7921_8021 7921 8021 2.886906e+00
R_8021_8121 8021 8121 4.146780e+00
R_8121_8221 8121 8221 9.952095e+00
R_8221_8321 8221 8321 1.631262e+00
R_8321_8421 8321 8421 2.151351e+00
R_8421_8521 8421 8521 7.786395e+00
R_8521_8621 8521 8621 4.808536e+00
R_8621_8721 8621 8721 9.186119e+00
R_8721_8821 8721 8821 3.213343e+00
R_8821_8921 8821 8921 5.798335e+00
R_8921_9021 8921 9021 8.012767e+00
R_9021_9121 9021 9121 1.203060e+00
R_9121_9221 9121 9221 6.681566e+00
R_9221_9321 9221 9321 7.291403e+00
R_9321_9421 9321 9421 2.666750e+00
R_9421_9521 9421 9521 3.177999e+00
R_9521_9621 9521 9621 5.132758e+00
R_9621_9721 9621 9721 7.475996e+00
R_9721_9821 9721 9821 9.794250e+00
R_9821_9921 9821 9921 2.536887e+00
R_22_122 22 122 3.839548e+00
R_122_222 122 222 2.409473e+00
R_222_322 222 322 4.773723e+00
R_322_422 322 422 4.445105e+00
R_422_522 422 522 1.412219e+00
R_522_622 522 622 3.191865e+00
R_622_722 622 722 9.909723e-01
R_722_822 722 822 1.600684e+00
R_822_922 822 922 8.873678e+00
R_922_1022 922 1022 1.410260e-01
R_1022_1122 1022 1122 9.784018e+00
R_1122_1222 1122 1222 4.481198e+00
R_1222_1322 1222 1322 5.948643e+00
R_1322_1422 1322 1422 6.707133e+00
R_1422_1522 1422 1522 6.757280e+00
R_1522_1622 1522 1622 7.846547e+00
R_1622_1722 1622 1722 9.381779e+00
R_1722_1822 1722 1822 7.399760e+00
R_1822_1922 1822 1922 3.805756e+00
R_1922_2022 1922 2022 4.838485e+00
R_2022_2122 2022 2122 3.575946e+00
R_2122_2222 2122 2222 9.022851e+00
R_2222_2322 2222 2322 4.054090e+00
R_2322_2422 2322 2422 9.841548e-01
R_2422_2522 2422 2522 1.741035e+00
R_2522_2622 2522 2622 8.120561e+00
R_2622_2722 2622 2722 4.390279e+00
R_2722_2822 2722 2822 5.108143e+00
R_2822_2922 2822 2922 5.801708e+00
R_2922_3022 2922 3022 6.806912e+00
R_3022_3122 3022 3122 8.597035e+00
R_3122_3222 3122 3222 7.808589e+00
R_3222_3322 3222 3322 9.614402e+00
R_3322_3422 3322 3422 9.209083e+00
R_3422_3522 3422 3522 5.690514e+00
R_3522_3622 3522 3622 4.986372e+00
R_3622_3722 3622 3722 9.814788e+00
R_3722_3822 3722 3822 1.081328e+00
R_3822_3922 3822 3922 3.272741e+00
R_3922_4022 3922 4022 8.450925e+00
R_4022_4122 4022 4122 4.359432e+00
R_4122_4222 4122 4222 4.731608e+00
R_4222_4322 4222 4322 3.691153e+00
R_4322_4422 4322 4422 4.593522e+00
R_4422_4522 4422 4522 7.641101e+00
R_4522_4622 4522 4622 3.857759e+00
R_4622_4722 4622 4722 6.754591e+00
R_4722_4822 4722 4822 1.906998e+00
R_4822_4922 4822 4922 5.164577e+00
R_4922_5022 4922 5022 7.181739e+00
R_5022_5122 5022 5122 4.880161e+00
R_5122_5222 5122 5222 3.803048e+00
R_5222_5322 5222 5322 5.329542e+00
R_5322_5422 5322 5422 2.246033e-01
R_5422_5522 5422 5522 6.337520e+00
R_5522_5622 5522 5622 1.735621e-01
R_5622_5722 5622 5722 3.224094e+00
R_5722_5822 5722 5822 7.004079e+00
R_5822_5922 5822 5922 4.370204e+00
R_5922_6022 5922 6022 1.220719e+00
R_6022_6122 6022 6122 8.346822e+00
R_6122_6222 6122 6222 3.822164e+00
R_6222_6322 6222 6322 8.570697e+00
R_6322_6422 6322 6422 8.080462e+00
R_6422_6522 6422 6522 5.969529e-01
R_6522_6622 6522 6622 8.386435e+00
R_6622_6722 6622 6722 5.977629e+00
R_6722_6822 6722 6822 9.112801e+00
R_6822_6922 6822 6922 8.894296e+00
R_6922_7022 6922 7022 9.756619e+00
R_7022_7122 7022 7122 4.974742e+00
R_7122_7222 7122 7222 8.952642e+00
R_7222_7322 7222 7322 6.888877e+00
R_7322_7422 7322 7422 7.690838e+00
R_7422_7522 7422 7522 6.543985e+00
R_7522_7622 7522 7622 3.760359e+00
R_7622_7722 7622 7722 7.596766e+00
R_7722_7822 7722 7822 8.914039e+00
R_7822_7922 7822 7922 2.362228e-01
R_7922_8022 7922 8022 1.968102e+00
R_8022_8122 8022 8122 5.720635e+00
R_8122_8222 8122 8222 3.899024e-01
R_8222_8322 8222 8322 7.043419e+00
R_8322_8422 8322 8422 3.999191e-01
R_8422_8522 8422 8522 3.261477e+00
R_8522_8622 8522 8622 3.516167e+00
R_8622_8722 8622 8722 1.490941e+00
R_8722_8822 8722 8822 6.876839e-01
R_8822_8922 8822 8922 5.272963e+00
R_8922_9022 8922 9022 9.804122e+00
R_9022_9122 9022 9122 8.386693e+00
R_9122_9222 9122 9222 7.209153e+00
R_9222_9322 9222 9322 6.619434e+00
R_9322_9422 9322 9422 2.556530e+00
R_9422_9522 9422 9522 7.409850e+00
R_9522_9622 9522 9622 8.351565e+00
R_9622_9722 9622 9722 9.456972e-01
R_9722_9822 9722 9822 2.679097e+00
R_9822_9922 9822 9922 1.884491e+00
R_23_123 23 123 7.270183e+00
R_123_223 123 223 3.967971e+00
R_223_323 223 323 7.274636e+00
R_323_423 323 423 3.848934e+00
R_423_523 423 523 4.438329e+00
R_523_623 523 623 3.198584e-01
R_623_723 623 723 3.915938e+00
R_723_823 723 823 6.404441e+00
R_823_923 823 923 9.341018e+00
R_923_1023 923 1023 5.486579e+00
R_1023_1123 1023 1123 3.380859e+00
R_1123_1223 1123 1223 3.360613e+00
R_1223_1323 1223 1323 1.429838e+00
R_1323_1423 1323 1423 4.149446e+00
R_1423_1523 1423 1523 8.526184e+00
R_1523_1623 1523 1623 4.743780e+00
R_1623_1723 1623 1723 9.804533e+00
R_1723_1823 1723 1823 6.016802e+00
R_1823_1923 1823 1923 8.671159e+00
R_1923_2023 1923 2023 4.992796e+00
R_2023_2123 2023 2123 6.851134e+00
R_2123_2223 2123 2223 3.346665e+00
R_2223_2323 2223 2323 1.718979e-01
R_2323_2423 2323 2423 9.397252e-01
R_2423_2523 2423 2523 8.004966e+00
R_2523_2623 2523 2623 6.125063e+00
R_2623_2723 2623 2723 2.193041e+00
R_2723_2823 2723 2823 9.790364e+00
R_2823_2923 2823 2923 6.171785e+00
R_2923_3023 2923 3023 1.333290e+00
R_3023_3123 3023 3123 1.044213e+00
R_3123_3223 3123 3223 1.102230e+00
R_3223_3323 3223 3323 2.801935e+00
R_3323_3423 3323 3423 3.987178e+00
R_3423_3523 3423 3523 7.297399e+00
R_3523_3623 3523 3623 1.189346e+00
R_3623_3723 3623 3723 8.634632e+00
R_3723_3823 3723 3823 3.034659e+00
R_3823_3923 3823 3923 3.560305e+00
R_3923_4023 3923 4023 9.901236e+00
R_4023_4123 4023 4123 1.063343e+00
R_4123_4223 4123 4223 7.645934e+00
R_4223_4323 4223 4323 5.807983e+00
R_4323_4423 4323 4423 4.037629e+00
R_4423_4523 4423 4523 7.570593e+00
R_4523_4623 4523 4623 8.353773e+00
R_4623_4723 4623 4723 6.641571e+00
R_4723_4823 4723 4823 1.821981e+00
R_4823_4923 4823 4923 9.170314e+00
R_4923_5023 4923 5023 9.319971e+00
R_5023_5123 5023 5123 2.438650e+00
R_5123_5223 5123 5223 2.863109e+00
R_5223_5323 5223 5323 2.950667e+00
R_5323_5423 5323 5423 7.186608e+00
R_5423_5523 5423 5523 3.965489e-01
R_5523_5623 5523 5623 5.576890e+00
R_5623_5723 5623 5723 6.290849e+00
R_5723_5823 5723 5823 8.580616e+00
R_5823_5923 5823 5923 9.815045e+00
R_5923_6023 5923 6023 4.061695e-01
R_6023_6123 6023 6123 4.607351e+00
R_6123_6223 6123 6223 2.684464e+00
R_6223_6323 6223 6323 4.965078e+00
R_6323_6423 6323 6423 1.371389e+00
R_6423_6523 6423 6523 3.133194e+00
R_6523_6623 6523 6623 2.730233e+00
R_6623_6723 6623 6723 9.276373e+00
R_6723_6823 6723 6823 3.287099e+00
R_6823_6923 6823 6923 1.445156e+00
R_6923_7023 6923 7023 8.028865e+00
R_7023_7123 7023 7123 1.363032e+00
R_7123_7223 7123 7223 9.377545e+00
R_7223_7323 7223 7323 6.405598e+00
R_7323_7423 7323 7423 4.729504e+00
R_7423_7523 7423 7523 8.954894e+00
R_7523_7623 7523 7623 2.644814e-01
R_7623_7723 7623 7723 1.393189e+00
R_7723_7823 7723 7823 7.318379e+00
R_7823_7923 7823 7923 5.129609e+00
R_7923_8023 7923 8023 5.811072e+00
R_8023_8123 8023 8123 8.662317e+00
R_8123_8223 8123 8223 6.307359e+00
R_8223_8323 8223 8323 7.816975e+00
R_8323_8423 8323 8423 3.182191e-01
R_8423_8523 8423 8523 4.691068e+00
R_8523_8623 8523 8623 5.000516e+00
R_8623_8723 8623 8723 4.913246e+00
R_8723_8823 8723 8823 8.467182e+00
R_8823_8923 8823 8923 7.340332e+00
R_8923_9023 8923 9023 5.960862e+00
R_9023_9123 9023 9123 7.301688e+00
R_9123_9223 9123 9223 2.969067e+00
R_9223_9323 9223 9323 7.798325e+00
R_9323_9423 9323 9423 1.482003e-01
R_9423_9523 9423 9523 7.854469e+00
R_9523_9623 9523 9623 1.261739e+00
R_9623_9723 9623 9723 6.652902e+00
R_9723_9823 9723 9823 8.670747e+00
R_9823_9923 9823 9923 1.931783e+00
R_24_124 24 124 7.695384e+00
R_124_224 124 224 9.194498e+00
R_224_324 224 324 7.216310e+00
R_324_424 324 424 4.225549e+00
R_424_524 424 524 1.083513e-01
R_524_624 524 624 1.422698e+00
R_624_724 624 724 9.696788e+00
R_724_824 724 824 4.896099e+00
R_824_924 824 924 5.751870e+00
R_924_1024 924 1024 4.912885e+00
R_1024_1124 1024 1124 7.002399e+00
R_1124_1224 1124 1224 3.974375e+00
R_1224_1324 1224 1324 9.236819e+00
R_1324_1424 1324 1424 2.906507e+00
R_1424_1524 1424 1524 5.175301e+00
R_1524_1624 1524 1624 1.429171e+00
R_1624_1724 1624 1724 7.116879e+00
R_1724_1824 1724 1824 2.381566e+00
R_1824_1924 1824 1924 9.117275e+00
R_1924_2024 1924 2024 5.688822e+00
R_2024_2124 2024 2124 3.920514e+00
R_2124_2224 2124 2224 9.137197e+00
R_2224_2324 2224 2324 6.081958e+00
R_2324_2424 2324 2424 7.129608e+00
R_2424_2524 2424 2524 8.127224e+00
R_2524_2624 2524 2624 7.984916e-01
R_2624_2724 2624 2724 3.998306e+00
R_2724_2824 2724 2824 2.383073e+00
R_2824_2924 2824 2924 1.611011e+00
R_2924_3024 2924 3024 6.920234e+00
R_3024_3124 3024 3124 4.753661e+00
R_3124_3224 3124 3224 8.174163e+00
R_3224_3324 3224 3324 8.060562e+00
R_3324_3424 3324 3424 3.216020e+00
R_3424_3524 3424 3524 6.163268e-01
R_3524_3624 3524 3624 2.543023e+00
R_3624_3724 3624 3724 5.166088e+00
R_3724_3824 3724 3824 1.862836e+00
R_3824_3924 3824 3924 3.116394e+00
R_3924_4024 3924 4024 4.242017e+00
R_4024_4124 4024 4124 8.723698e+00
R_4124_4224 4124 4224 2.907201e-01
R_4224_4324 4224 4324 1.053263e+00
R_4324_4424 4324 4424 3.648162e+00
R_4424_4524 4424 4524 7.560043e-01
R_4524_4624 4524 4624 8.963644e-02
R_4624_4724 4624 4724 7.714683e-01
R_4724_4824 4724 4824 9.294824e+00
R_4824_4924 4824 4924 2.955091e+00
R_4924_5024 4924 5024 7.629207e+00
R_5024_5124 5024 5124 8.816875e+00
R_5124_5224 5124 5224 3.632705e+00
R_5224_5324 5224 5324 8.033526e-01
R_5324_5424 5324 5424 7.128732e+00
R_5424_5524 5424 5524 7.481965e+00
R_5524_5624 5524 5624 6.585562e+00
R_5624_5724 5624 5724 4.174192e+00
R_5724_5824 5724 5824 8.401827e+00
R_5824_5924 5824 5924 1.957969e+00
R_5924_6024 5924 6024 7.700037e+00
R_6024_6124 6024 6124 1.693944e+00
R_6124_6224 6124 6224 3.498826e+00
R_6224_6324 6224 6324 4.265562e+00
R_6324_6424 6324 6424 7.872917e+00
R_6424_6524 6424 6524 5.236325e+00
R_6524_6624 6524 6624 1.893508e-01
R_6624_6724 6624 6724 9.141228e+00
R_6724_6824 6724 6824 8.582202e+00
R_6824_6924 6824 6924 6.194721e+00
R_6924_7024 6924 7024 7.233744e+00
R_7024_7124 7024 7124 6.883430e-01
R_7124_7224 7124 7224 4.589837e+00
R_7224_7324 7224 7324 1.182958e+00
R_7324_7424 7324 7424 7.838854e+00
R_7424_7524 7424 7524 8.105795e+00
R_7524_7624 7524 7624 1.717717e+00
R_7624_7724 7624 7724 1.874470e+00
R_7724_7824 7724 7824 3.728648e-01
R_7824_7924 7824 7924 7.751923e+00
R_7924_8024 7924 8024 3.263941e+00
R_8024_8124 8024 8124 7.336908e-01
R_8124_8224 8124 8224 7.506364e+00
R_8224_8324 8224 8324 5.139689e+00
R_8324_8424 8324 8424 2.394030e+00
R_8424_8524 8424 8524 2.472039e+00
R_8524_8624 8524 8624 2.842221e-01
R_8624_8724 8624 8724 5.560956e+00
R_8724_8824 8724 8824 6.666872e+00
R_8824_8924 8824 8924 8.043270e-01
R_8924_9024 8924 9024 2.819908e+00
R_9024_9124 9024 9124 4.251192e+00
R_9124_9224 9124 9224 9.014394e+00
R_9224_9324 9224 9324 8.164060e+00
R_9324_9424 9324 9424 7.556221e+00
R_9424_9524 9424 9524 5.440938e+00
R_9524_9624 9524 9624 5.002527e+00
R_9624_9724 9624 9724 1.542759e+00
R_9724_9824 9724 9824 9.558286e+00
R_9824_9924 9824 9924 1.161695e+00
R_25_125 25 125 6.838495e+00
R_125_225 125 225 7.666953e+00
R_225_325 225 325 9.052319e+00
R_325_425 325 425 3.854804e+00
R_425_525 425 525 2.213804e+00
R_525_625 525 625 1.826727e+00
R_625_725 625 725 5.043822e+00
R_725_825 725 825 5.054969e+00
R_825_925 825 925 4.771198e+00
R_925_1025 925 1025 9.219245e+00
R_1025_1125 1025 1125 2.636478e-01
R_1125_1225 1125 1225 3.162086e+00
R_1225_1325 1225 1325 7.106002e+00
R_1325_1425 1325 1425 4.221319e+00
R_1425_1525 1425 1525 4.652373e+00
R_1525_1625 1525 1625 3.937315e+00
R_1625_1725 1625 1725 5.937177e+00
R_1725_1825 1725 1825 4.907723e+00
R_1825_1925 1825 1925 4.522634e+00
R_1925_2025 1925 2025 3.325523e+00
R_2025_2125 2025 2125 6.930526e+00
R_2125_2225 2125 2225 9.665754e+00
R_2225_2325 2225 2325 4.869280e+00
R_2325_2425 2325 2425 5.153020e+00
R_2425_2525 2425 2525 5.416746e+00
R_2525_2625 2525 2625 3.426892e+00
R_2625_2725 2625 2725 5.544943e-01
R_2725_2825 2725 2825 6.919377e+00
R_2825_2925 2825 2925 2.238012e+00
R_2925_3025 2925 3025 3.621758e+00
R_3025_3125 3025 3125 1.419739e+00
R_3125_3225 3125 3225 3.711338e+00
R_3225_3325 3225 3325 1.164164e+00
R_3325_3425 3325 3425 6.285008e+00
R_3425_3525 3425 3525 2.036292e+00
R_3525_3625 3525 3625 5.455509e+00
R_3625_3725 3625 3725 6.776252e+00
R_3725_3825 3725 3825 9.993660e+00
R_3825_3925 3825 3925 8.152782e+00
R_3925_4025 3925 4025 7.477498e+00
R_4025_4125 4025 4125 5.616575e+00
R_4125_4225 4125 4225 5.481693e+00
R_4225_4325 4225 4325 6.367772e+00
R_4325_4425 4325 4425 6.814782e+00
R_4425_4525 4425 4525 6.102036e+00
R_4525_4625 4525 4625 1.172492e+00
R_4625_4725 4625 4725 3.655027e+00
R_4725_4825 4725 4825 7.200963e+00
R_4825_4925 4825 4925 9.198325e+00
R_4925_5025 4925 5025 2.360967e+00
R_5025_5125 5025 5125 3.689901e+00
R_5125_5225 5125 5225 5.286444e-01
R_5225_5325 5225 5325 3.534226e+00
R_5325_5425 5325 5425 2.612447e+00
R_5425_5525 5425 5525 1.868489e+00
R_5525_5625 5525 5625 9.690041e+00
R_5625_5725 5625 5725 4.580280e+00
R_5725_5825 5725 5825 5.828640e+00
R_5825_5925 5825 5925 3.108272e-01
R_5925_6025 5925 6025 7.834245e+00
R_6025_6125 6025 6125 4.382103e+00
R_6125_6225 6125 6225 5.639726e+00
R_6225_6325 6225 6325 4.354218e+00
R_6325_6425 6325 6425 3.447495e-01
R_6425_6525 6425 6525 6.038753e+00
R_6525_6625 6525 6625 3.571956e-01
R_6625_6725 6625 6725 2.383757e+00
R_6725_6825 6725 6825 4.636550e-02
R_6825_6925 6825 6925 1.843218e+00
R_6925_7025 6925 7025 8.375298e+00
R_7025_7125 7025 7125 2.820756e+00
R_7125_7225 7125 7225 6.701633e+00
R_7225_7325 7225 7325 1.625422e+00
R_7325_7425 7325 7425 2.998243e+00
R_7425_7525 7425 7525 1.050601e+00
R_7525_7625 7525 7625 9.141741e+00
R_7625_7725 7625 7725 4.319037e+00
R_7725_7825 7725 7825 2.157150e+00
R_7825_7925 7825 7925 3.103815e+00
R_7925_8025 7925 8025 1.009233e+00
R_8025_8125 8025 8125 7.416996e+00
R_8125_8225 8125 8225 5.006258e+00
R_8225_8325 8225 8325 8.007429e+00
R_8325_8425 8325 8425 6.428270e+00
R_8425_8525 8425 8525 9.265389e+00
R_8525_8625 8525 8625 8.133044e+00
R_8625_8725 8625 8725 9.260999e+00
R_8725_8825 8725 8825 7.581008e+00
R_8825_8925 8825 8925 9.778016e+00
R_8925_9025 8925 9025 3.788655e+00
R_9025_9125 9025 9125 8.960796e+00
R_9125_9225 9125 9225 7.305800e+00
R_9225_9325 9225 9325 7.755629e+00
R_9325_9425 9325 9425 9.515311e+00
R_9425_9525 9425 9525 8.332265e+00
R_9525_9625 9525 9625 2.901485e+00
R_9625_9725 9625 9725 2.305621e+00
R_9725_9825 9725 9825 4.583265e+00
R_9825_9925 9825 9925 4.088713e+00
R_26_126 26 126 7.281298e+00
R_126_226 126 226 9.918634e+00
R_226_326 226 326 6.393421e+00
R_326_426 326 426 2.241023e+00
R_426_526 426 526 7.285268e+00
R_526_626 526 626 4.026281e+00
R_626_726 626 726 1.967039e+00
R_726_826 726 826 8.014620e+00
R_826_926 826 926 3.613293e+00
R_926_1026 926 1026 2.596128e+00
R_1026_1126 1026 1126 7.350026e+00
R_1126_1226 1126 1226 4.442953e+00
R_1226_1326 1226 1326 7.403301e+00
R_1326_1426 1326 1426 7.000360e+00
R_1426_1526 1426 1526 7.682621e+00
R_1526_1626 1526 1626 7.868907e-01
R_1626_1726 1626 1726 5.128511e+00
R_1726_1826 1726 1826 7.769892e+00
R_1826_1926 1826 1926 6.612381e+00
R_1926_2026 1926 2026 3.745980e+00
R_2026_2126 2026 2126 8.443414e+00
R_2126_2226 2126 2226 4.556939e+00
R_2226_2326 2226 2326 1.954246e+00
R_2326_2426 2326 2426 4.638859e+00
R_2426_2526 2426 2526 6.909503e+00
R_2526_2626 2526 2626 8.609209e+00
R_2626_2726 2626 2726 6.018485e+00
R_2726_2826 2726 2826 5.706354e-01
R_2826_2926 2826 2926 1.864319e-01
R_2926_3026 2926 3026 7.824277e+00
R_3026_3126 3026 3126 6.092556e+00
R_3126_3226 3126 3226 9.663529e+00
R_3226_3326 3226 3326 6.631286e+00
R_3326_3426 3326 3426 9.486314e+00
R_3426_3526 3426 3526 1.466477e+00
R_3526_3626 3526 3626 9.887328e+00
R_3626_3726 3626 3726 9.612303e+00
R_3726_3826 3726 3826 9.166426e-01
R_3826_3926 3826 3926 1.043594e+00
R_3926_4026 3926 4026 1.814131e+00
R_4026_4126 4026 4126 5.497379e+00
R_4126_4226 4126 4226 6.407262e+00
R_4226_4326 4226 4326 4.284651e+00
R_4326_4426 4326 4426 5.596533e+00
R_4426_4526 4426 4526 6.803603e+00
R_4526_4626 4526 4626 1.810775e+00
R_4626_4726 4626 4726 6.743597e+00
R_4726_4826 4726 4826 3.924726e+00
R_4826_4926 4826 4926 9.165982e+00
R_4926_5026 4926 5026 3.264690e+00
R_5026_5126 5026 5126 6.676328e+00
R_5126_5226 5126 5226 1.293090e+00
R_5226_5326 5226 5326 3.820966e+00
R_5326_5426 5326 5426 7.761089e+00
R_5426_5526 5426 5526 7.911509e+00
R_5526_5626 5526 5626 4.123893e-01
R_5626_5726 5626 5726 9.453248e+00
R_5726_5826 5726 5826 5.702518e+00
R_5826_5926 5826 5926 2.270727e+00
R_5926_6026 5926 6026 3.824763e+00
R_6026_6126 6026 6126 1.232511e-01
R_6126_6226 6126 6226 7.324400e+00
R_6226_6326 6226 6326 6.839047e+00
R_6326_6426 6326 6426 6.320131e-01
R_6426_6526 6426 6526 7.537187e+00
R_6526_6626 6526 6626 8.138698e+00
R_6626_6726 6626 6726 4.541422e-01
R_6726_6826 6726 6826 9.905746e+00
R_6826_6926 6826 6926 2.401733e+00
R_6926_7026 6926 7026 6.645706e+00
R_7026_7126 7026 7126 7.225405e+00
R_7126_7226 7126 7226 6.418577e+00
R_7226_7326 7226 7326 5.386206e+00
R_7326_7426 7326 7426 2.330470e+00
R_7426_7526 7426 7526 6.149313e+00
R_7526_7626 7526 7626 1.233625e+00
R_7626_7726 7626 7726 8.586571e+00
R_7726_7826 7726 7826 7.392977e+00
R_7826_7926 7826 7926 8.743418e+00
R_7926_8026 7926 8026 1.157059e+00
R_8026_8126 8026 8126 4.112110e+00
R_8126_8226 8126 8226 1.733188e+00
R_8226_8326 8226 8326 3.262169e+00
R_8326_8426 8326 8426 5.445849e+00
R_8426_8526 8426 8526 3.944593e+00
R_8526_8626 8526 8626 9.338267e+00
R_8626_8726 8626 8726 6.383193e+00
R_8726_8826 8726 8826 9.452095e+00
R_8826_8926 8826 8926 3.425011e+00
R_8926_9026 8926 9026 4.620719e+00
R_9026_9126 9026 9126 5.420343e+00
R_9126_9226 9126 9226 8.752565e+00
R_9226_9326 9226 9326 8.993553e+00
R_9326_9426 9326 9426 6.977088e+00
R_9426_9526 9426 9526 5.150741e+00
R_9526_9626 9526 9626 8.370299e+00
R_9626_9726 9626 9726 7.714501e+00
R_9726_9826 9726 9826 1.487709e+00
R_9826_9926 9826 9926 8.222787e+00
R_27_127 27 127 3.717833e+00
R_127_227 127 227 1.982109e+00
R_227_327 227 327 7.999782e+00
R_327_427 327 427 5.518568e+00
R_427_527 427 527 1.540979e-02
R_527_627 527 627 2.970815e+00
R_627_727 627 727 5.709483e+00
R_727_827 727 827 8.039859e+00
R_827_927 827 927 7.931969e+00
R_927_1027 927 1027 1.761160e+00
R_1027_1127 1027 1127 8.332129e+00
R_1127_1227 1127 1227 4.305060e+00
R_1227_1327 1227 1327 5.319357e+00
R_1327_1427 1327 1427 3.542611e-01
R_1427_1527 1427 1527 9.505102e+00
R_1527_1627 1527 1627 5.094358e+00
R_1627_1727 1627 1727 3.523931e+00
R_1727_1827 1727 1827 9.365684e+00
R_1827_1927 1827 1927 3.495999e+00
R_1927_2027 1927 2027 5.595179e+00
R_2027_2127 2027 2127 7.770380e+00
R_2127_2227 2127 2227 6.693133e+00
R_2227_2327 2227 2327 3.737185e-01
R_2327_2427 2327 2427 1.550860e+00
R_2427_2527 2427 2527 7.811741e+00
R_2527_2627 2527 2627 8.931059e+00
R_2627_2727 2627 2727 3.735304e-02
R_2727_2827 2727 2827 8.474924e+00
R_2827_2927 2827 2927 8.741304e+00
R_2927_3027 2927 3027 9.157836e+00
R_3027_3127 3027 3127 8.537020e+00
R_3127_3227 3127 3227 4.249306e+00
R_3227_3327 3227 3327 5.318245e+00
R_3327_3427 3327 3427 5.825282e+00
R_3427_3527 3427 3527 8.108435e+00
R_3527_3627 3527 3627 1.926782e+00
R_3627_3727 3627 3727 7.847526e+00
R_3727_3827 3727 3827 8.325666e+00
R_3827_3927 3827 3927 9.502642e+00
R_3927_4027 3927 4027 1.738083e+00
R_4027_4127 4027 4127 8.262971e+00
R_4127_4227 4127 4227 7.519975e+00
R_4227_4327 4227 4327 6.261525e+00
R_4327_4427 4327 4427 9.456376e+00
R_4427_4527 4427 4527 7.280671e+00
R_4527_4627 4527 4627 9.280706e+00
R_4627_4727 4627 4727 7.542570e+00
R_4727_4827 4727 4827 3.332201e+00
R_4827_4927 4827 4927 9.671444e+00
R_4927_5027 4927 5027 8.095013e+00
R_5027_5127 5027 5127 5.489574e+00
R_5127_5227 5127 5227 8.319051e+00
R_5227_5327 5227 5327 7.121627e+00
R_5327_5427 5327 5427 6.304843e+00
R_5427_5527 5427 5527 9.052188e+00
R_5527_5627 5527 5627 8.690449e-01
R_5627_5727 5627 5727 7.741339e+00
R_5727_5827 5727 5827 8.828750e+00
R_5827_5927 5827 5927 2.955433e+00
R_5927_6027 5927 6027 3.902693e+00
R_6027_6127 6027 6127 6.426667e-01
R_6127_6227 6127 6227 4.642601e+00
R_6227_6327 6227 6327 6.817062e+00
R_6327_6427 6327 6427 1.323865e+00
R_6427_6527 6427 6527 5.543421e+00
R_6527_6627 6527 6627 8.308228e+00
R_6627_6727 6627 6727 2.925916e+00
R_6727_6827 6727 6827 5.953900e+00
R_6827_6927 6827 6927 1.295665e-01
R_6927_7027 6927 7027 5.928707e+00
R_7027_7127 7027 7127 2.169213e+00
R_7127_7227 7127 7227 2.513193e+00
R_7227_7327 7227 7327 8.485030e+00
R_7327_7427 7327 7427 7.000318e+00
R_7427_7527 7427 7527 8.748740e+00
R_7527_7627 7527 7627 4.249963e+00
R_7627_7727 7627 7727 6.920996e+00
R_7727_7827 7727 7827 4.100846e+00
R_7827_7927 7827 7927 6.919860e-01
R_7927_8027 7927 8027 1.981672e+00
R_8027_8127 8027 8127 2.674296e+00
R_8127_8227 8127 8227 5.924977e-01
R_8227_8327 8227 8327 4.682751e+00
R_8327_8427 8327 8427 3.560974e+00
R_8427_8527 8427 8527 1.680307e+00
R_8527_8627 8527 8627 6.323961e+00
R_8627_8727 8627 8727 5.880016e+00
R_8727_8827 8727 8827 6.893045e+00
R_8827_8927 8827 8927 4.720990e+00
R_8927_9027 8927 9027 2.062626e+00
R_9027_9127 9027 9127 4.271348e+00
R_9127_9227 9127 9227 3.174713e+00
R_9227_9327 9227 9327 7.572480e-01
R_9327_9427 9327 9427 2.992452e+00
R_9427_9527 9427 9527 8.898881e+00
R_9527_9627 9527 9627 6.876094e+00
R_9627_9727 9627 9727 4.763612e+00
R_9727_9827 9727 9827 4.141638e+00
R_9827_9927 9827 9927 2.569653e+00
R_28_128 28 128 4.063095e+00
R_128_228 128 228 2.305602e+00
R_228_328 228 328 5.229405e+00
R_328_428 328 428 2.282119e+00
R_428_528 428 528 7.651734e+00
R_528_628 528 628 4.546114e+00
R_628_728 628 728 3.011432e+00
R_728_828 728 828 6.878471e+00
R_828_928 828 928 6.296808e+00
R_928_1028 928 1028 4.369761e+00
R_1028_1128 1028 1128 8.547983e+00
R_1128_1228 1128 1228 3.241726e+00
R_1228_1328 1228 1328 9.670098e-02
R_1328_1428 1328 1428 1.086943e+00
R_1428_1528 1428 1528 1.092065e-01
R_1528_1628 1528 1628 6.689410e+00
R_1628_1728 1628 1728 2.113390e+00
R_1728_1828 1728 1828 4.022282e+00
R_1828_1928 1828 1928 9.876680e+00
R_1928_2028 1928 2028 3.192830e+00
R_2028_2128 2028 2128 6.046052e-01
R_2128_2228 2128 2228 7.104498e+00
R_2228_2328 2228 2328 4.102525e+00
R_2328_2428 2328 2428 4.332331e+00
R_2428_2528 2428 2528 7.914330e+00
R_2528_2628 2528 2628 2.591384e+00
R_2628_2728 2628 2728 5.044524e+00
R_2728_2828 2728 2828 2.149285e+00
R_2828_2928 2828 2928 6.729984e+00
R_2928_3028 2928 3028 5.050854e+00
R_3028_3128 3028 3128 5.168288e+00
R_3128_3228 3128 3228 6.759564e+00
R_3228_3328 3228 3328 7.925213e+00
R_3328_3428 3328 3428 2.968041e+00
R_3428_3528 3428 3528 3.371797e+00
R_3528_3628 3528 3628 3.101565e-01
R_3628_3728 3628 3728 1.819648e+00
R_3728_3828 3728 3828 3.420288e+00
R_3828_3928 3828 3928 3.614458e+00
R_3928_4028 3928 4028 3.461828e+00
R_4028_4128 4028 4128 2.897971e+00
R_4128_4228 4128 4228 7.422995e+00
R_4228_4328 4228 4328 4.449663e+00
R_4328_4428 4328 4428 9.147819e+00
R_4428_4528 4428 4528 5.718364e+00
R_4528_4628 4528 4628 4.166804e-01
R_4628_4728 4628 4728 2.732338e-01
R_4728_4828 4728 4828 8.770433e+00
R_4828_4928 4828 4928 9.299747e+00
R_4928_5028 4928 5028 6.027467e+00
R_5028_5128 5028 5128 6.615431e-02
R_5128_5228 5128 5228 9.097691e+00
R_5228_5328 5228 5328 3.036583e-02
R_5328_5428 5328 5428 1.801602e-01
R_5428_5528 5428 5528 9.509533e+00
R_5528_5628 5528 5628 7.126537e+00
R_5628_5728 5628 5728 3.581676e+00
R_5728_5828 5728 5828 2.308023e+00
R_5828_5928 5828 5928 4.067259e+00
R_5928_6028 5928 6028 5.497289e+00
R_6028_6128 6028 6128 9.902025e+00
R_6128_6228 6128 6228 1.294747e+00
R_6228_6328 6228 6328 5.471327e+00
R_6328_6428 6328 6428 2.065881e+00
R_6428_6528 6428 6528 7.389524e+00
R_6528_6628 6528 6628 1.243381e+00
R_6628_6728 6628 6728 6.147587e+00
R_6728_6828 6728 6828 2.336930e+00
R_6828_6928 6828 6928 7.431298e+00
R_6928_7028 6928 7028 1.467331e+00
R_7028_7128 7028 7128 8.940161e+00
R_7128_7228 7128 7228 8.609676e+00
R_7228_7328 7228 7328 4.649296e+00
R_7328_7428 7328 7428 2.398879e+00
R_7428_7528 7428 7528 9.674953e-01
R_7528_7628 7528 7628 2.816784e+00
R_7628_7728 7628 7728 5.900386e+00
R_7728_7828 7728 7828 5.819950e+00
R_7828_7928 7828 7928 4.680020e+00
R_7928_8028 7928 8028 6.983851e+00
R_8028_8128 8028 8128 5.909600e+00
R_8128_8228 8128 8228 5.935217e+00
R_8228_8328 8228 8328 9.080681e+00
R_8328_8428 8328 8428 2.516485e+00
R_8428_8528 8428 8528 2.388865e+00
R_8528_8628 8528 8628 4.580802e+00
R_8628_8728 8628 8728 9.434236e+00
R_8728_8828 8728 8828 2.297799e+00
R_8828_8928 8828 8928 3.926261e+00
R_8928_9028 8928 9028 9.669834e+00
R_9028_9128 9028 9128 7.105260e+00
R_9128_9228 9128 9228 2.998979e-01
R_9228_9328 9228 9328 7.604221e+00
R_9328_9428 9328 9428 2.699135e+00
R_9428_9528 9428 9528 5.498522e+00
R_9528_9628 9528 9628 5.338560e+00
R_9628_9728 9628 9728 1.967205e+00
R_9728_9828 9728 9828 5.717345e+00
R_9828_9928 9828 9928 4.866876e+00
R_29_129 29 129 8.845545e+00
R_129_229 129 229 9.023826e+00
R_229_329 229 329 8.597639e+00
R_329_429 329 429 1.685609e+00
R_429_529 429 529 2.854335e+00
R_529_629 529 629 2.882620e+00
R_629_729 629 729 2.755831e+00
R_729_829 729 829 9.644754e+00
R_829_929 829 929 6.142099e+00
R_929_1029 929 1029 6.114015e+00
R_1029_1129 1029 1129 3.217227e+00
R_1129_1229 1129 1229 9.659572e+00
R_1229_1329 1229 1329 1.197893e+00
R_1329_1429 1329 1429 6.419691e+00
R_1429_1529 1429 1529 2.512677e+00
R_1529_1629 1529 1629 9.312961e+00
R_1629_1729 1629 1729 7.242459e+00
R_1729_1829 1729 1829 3.364158e+00
R_1829_1929 1829 1929 6.290808e+00
R_1929_2029 1929 2029 4.249849e+00
R_2029_2129 2029 2129 4.442779e+00
R_2129_2229 2129 2229 5.211590e+00
R_2229_2329 2229 2329 4.595643e+00
R_2329_2429 2329 2429 7.208983e+00
R_2429_2529 2429 2529 4.454631e+00
R_2529_2629 2529 2629 3.036654e+00
R_2629_2729 2629 2729 3.998576e+00
R_2729_2829 2729 2829 5.189553e+00
R_2829_2929 2829 2929 6.389075e-01
R_2929_3029 2929 3029 6.244033e+00
R_3029_3129 3029 3129 5.415329e-01
R_3129_3229 3129 3229 1.261781e+00
R_3229_3329 3229 3329 7.820845e+00
R_3329_3429 3329 3429 8.811354e+00
R_3429_3529 3429 3529 1.159335e+00
R_3529_3629 3529 3629 3.871236e-01
R_3629_3729 3629 3729 4.534149e+00
R_3729_3829 3729 3829 2.607056e-01
R_3829_3929 3829 3929 3.361071e+00
R_3929_4029 3929 4029 6.386917e+00
R_4029_4129 4029 4129 8.606507e+00
R_4129_4229 4129 4229 9.407776e-01
R_4229_4329 4229 4329 1.273734e+00
R_4329_4429 4329 4429 6.007687e+00
R_4429_4529 4429 4529 6.134620e+00
R_4529_4629 4529 4629 5.268503e+00
R_4629_4729 4629 4729 2.660101e+00
R_4729_4829 4729 4829 1.259862e+00
R_4829_4929 4829 4929 2.256474e+00
R_4929_5029 4929 5029 7.151954e+00
R_5029_5129 5029 5129 5.914876e+00
R_5129_5229 5129 5229 7.866055e+00
R_5229_5329 5229 5329 5.066359e+00
R_5329_5429 5329 5429 2.414418e+00
R_5429_5529 5429 5529 1.722134e+00
R_5529_5629 5529 5629 8.715425e+00
R_5629_5729 5629 5729 6.365258e+00
R_5729_5829 5729 5829 9.975983e+00
R_5829_5929 5829 5929 3.506792e+00
R_5929_6029 5929 6029 4.196410e+00
R_6029_6129 6029 6129 3.527641e+00
R_6129_6229 6129 6229 5.242053e+00
R_6229_6329 6229 6329 7.282268e+00
R_6329_6429 6329 6429 3.875831e-01
R_6429_6529 6429 6529 3.373652e+00
R_6529_6629 6529 6629 2.452142e+00
R_6629_6729 6629 6729 3.569078e+00
R_6729_6829 6729 6829 2.067161e+00
R_6829_6929 6829 6929 6.478487e+00
R_6929_7029 6929 7029 1.460830e+00
R_7029_7129 7029 7129 4.553005e+00
R_7129_7229 7129 7229 7.661759e+00
R_7229_7329 7229 7329 1.083550e+00
R_7329_7429 7329 7429 1.075256e+00
R_7429_7529 7429 7529 1.049720e+00
R_7529_7629 7529 7629 2.995034e-01
R_7629_7729 7629 7729 8.442011e-01
R_7729_7829 7729 7829 4.921012e+00
R_7829_7929 7829 7929 8.076588e+00
R_7929_8029 7929 8029 1.786955e+00
R_8029_8129 8029 8129 2.434734e-01
R_8129_8229 8129 8229 2.015990e+00
R_8229_8329 8229 8329 9.938339e+00
R_8329_8429 8329 8429 5.794311e+00
R_8429_8529 8429 8529 9.436647e+00
R_8529_8629 8529 8629 2.979194e+00
R_8629_8729 8629 8729 8.626881e+00
R_8729_8829 8729 8829 4.789251e+00
R_8829_8929 8829 8929 2.478044e+00
R_8929_9029 8929 9029 4.552937e+00
R_9029_9129 9029 9129 9.264885e+00
R_9129_9229 9129 9229 3.139946e+00
R_9229_9329 9229 9329 1.389683e+00
R_9329_9429 9329 9429 8.992913e+00
R_9429_9529 9429 9529 9.312652e+00
R_9529_9629 9529 9629 9.164431e+00
R_9629_9729 9629 9729 6.955937e+00
R_9729_9829 9729 9829 9.043190e+00
R_9829_9929 9829 9929 7.135417e+00
R_30_130 30 130 1.256374e-02
R_130_230 130 230 4.373055e+00
R_230_330 230 330 4.671275e+00
R_330_430 330 430 5.123412e+00
R_430_530 430 530 5.532350e+00
R_530_630 530 630 5.775632e+00
R_630_730 630 730 4.558186e+00
R_730_830 730 830 6.252634e+00
R_830_930 830 930 6.613059e+00
R_930_1030 930 1030 1.952374e+00
R_1030_1130 1030 1130 5.727296e+00
R_1130_1230 1130 1230 5.265538e+00
R_1230_1330 1230 1330 7.869913e+00
R_1330_1430 1330 1430 3.407857e+00
R_1430_1530 1430 1530 8.805880e+00
R_1530_1630 1530 1630 8.419913e-01
R_1630_1730 1630 1730 3.614454e+00
R_1730_1830 1730 1830 7.462915e+00
R_1830_1930 1830 1930 7.979612e+00
R_1930_2030 1930 2030 2.864067e+00
R_2030_2130 2030 2130 6.429572e+00
R_2130_2230 2130 2230 6.606100e+00
R_2230_2330 2230 2330 3.466714e-01
R_2330_2430 2330 2430 1.869786e+00
R_2430_2530 2430 2530 1.585736e+00
R_2530_2630 2530 2630 3.747125e+00
R_2630_2730 2630 2730 3.782137e+00
R_2730_2830 2730 2830 7.016011e+00
R_2830_2930 2830 2930 1.263604e+00
R_2930_3030 2930 3030 6.902788e+00
R_3030_3130 3030 3130 2.535234e+00
R_3130_3230 3130 3230 7.041221e+00
R_3230_3330 3230 3330 3.874397e+00
R_3330_3430 3330 3430 4.745727e+00
R_3430_3530 3430 3530 7.837017e+00
R_3530_3630 3530 3630 1.626549e+00
R_3630_3730 3630 3730 7.555944e+00
R_3730_3830 3730 3830 7.458469e+00
R_3830_3930 3830 3930 3.793435e+00
R_3930_4030 3930 4030 7.490500e+00
R_4030_4130 4030 4130 4.096446e+00
R_4130_4230 4130 4230 9.600678e+00
R_4230_4330 4230 4330 5.108422e+00
R_4330_4430 4330 4430 4.841465e+00
R_4430_4530 4430 4530 1.366707e+00
R_4530_4630 4530 4630 3.288123e+00
R_4630_4730 4630 4730 7.531570e+00
R_4730_4830 4730 4830 2.718204e+00
R_4830_4930 4830 4930 7.050116e+00
R_4930_5030 4930 5030 8.754567e+00
R_5030_5130 5030 5130 1.774797e+00
R_5130_5230 5130 5230 3.856568e+00
R_5230_5330 5230 5330 4.033537e-01
R_5330_5430 5330 5430 9.277257e+00
R_5430_5530 5430 5530 8.909479e+00
R_5530_5630 5530 5630 7.920735e+00
R_5630_5730 5630 5730 3.012770e+00
R_5730_5830 5730 5830 7.253971e+00
R_5830_5930 5830 5930 5.485514e-01
R_5930_6030 5930 6030 9.722482e+00
R_6030_6130 6030 6130 5.090889e+00
R_6130_6230 6130 6230 1.188504e+00
R_6230_6330 6230 6330 7.173322e+00
R_6330_6430 6330 6430 5.971958e+00
R_6430_6530 6430 6530 1.866242e+00
R_6530_6630 6530 6630 5.240073e+00
R_6630_6730 6630 6730 8.167467e+00
R_6730_6830 6730 6830 8.152882e+00
R_6830_6930 6830 6930 8.290763e+00
R_6930_7030 6930 7030 9.354129e+00
R_7030_7130 7030 7130 6.555755e+00
R_7130_7230 7130 7230 7.253808e+00
R_7230_7330 7230 7330 1.709081e+00
R_7330_7430 7330 7430 5.732565e+00
R_7430_7530 7430 7530 2.773031e+00
R_7530_7630 7530 7630 6.193576e+00
R_7630_7730 7630 7730 7.030199e+00
R_7730_7830 7730 7830 1.229849e-01
R_7830_7930 7830 7930 3.097120e+00
R_7930_8030 7930 8030 7.511967e+00
R_8030_8130 8030 8130 6.912311e+00
R_8130_8230 8130 8230 1.895212e+00
R_8230_8330 8230 8330 5.608628e+00
R_8330_8430 8330 8430 8.065003e+00
R_8430_8530 8430 8530 5.705368e+00
R_8530_8630 8530 8630 1.209884e-01
R_8630_8730 8630 8730 9.391771e+00
R_8730_8830 8730 8830 2.931723e+00
R_8830_8930 8830 8930 7.715492e+00
R_8930_9030 8930 9030 9.234500e+00
R_9030_9130 9030 9130 4.474220e+00
R_9130_9230 9130 9230 9.466876e+00
R_9230_9330 9230 9330 4.664201e+00
R_9330_9430 9330 9430 1.748081e+00
R_9430_9530 9430 9530 4.709952e+00
R_9530_9630 9530 9630 6.553607e+00
R_9630_9730 9630 9730 2.628295e+00
R_9730_9830 9730 9830 8.049465e+00
R_9830_9930 9830 9930 7.613254e+00
R_31_131 31 131 7.079425e+00
R_131_231 131 231 9.528803e+00
R_231_331 231 331 3.805079e-01
R_331_431 331 431 6.056649e+00
R_431_531 431 531 5.523514e+00
R_531_631 531 631 7.548179e+00
R_631_731 631 731 8.420780e+00
R_731_831 731 831 9.898670e+00
R_831_931 831 931 8.617113e+00
R_931_1031 931 1031 6.911494e+00
R_1031_1131 1031 1131 1.839068e+00
R_1131_1231 1131 1231 6.060629e+00
R_1231_1331 1231 1331 2.622682e+00
R_1331_1431 1331 1431 5.035730e-01
R_1431_1531 1431 1531 1.549395e+00
R_1531_1631 1531 1631 9.257571e+00
R_1631_1731 1631 1731 9.870982e+00
R_1731_1831 1731 1831 7.776332e+00
R_1831_1931 1831 1931 5.836794e+00
R_1931_2031 1931 2031 4.610365e+00
R_2031_2131 2031 2131 2.497370e+00
R_2131_2231 2131 2231 5.014074e+00
R_2231_2331 2231 2331 5.506285e+00
R_2331_2431 2331 2431 7.237234e+00
R_2431_2531 2431 2531 9.067333e-01
R_2531_2631 2531 2631 8.377755e+00
R_2631_2731 2631 2731 1.474657e-01
R_2731_2831 2731 2831 7.293115e+00
R_2831_2931 2831 2931 4.025702e+00
R_2931_3031 2931 3031 7.754379e+00
R_3031_3131 3031 3131 5.579269e+00
R_3131_3231 3131 3231 7.373956e+00
R_3231_3331 3231 3331 7.254036e+00
R_3331_3431 3331 3431 6.306778e+00
R_3431_3531 3431 3531 7.090079e+00
R_3531_3631 3531 3631 5.363914e+00
R_3631_3731 3631 3731 7.356545e+00
R_3731_3831 3731 3831 5.912076e+00
R_3831_3931 3831 3931 8.078614e+00
R_3931_4031 3931 4031 5.436767e+00
R_4031_4131 4031 4131 6.058945e+00
R_4131_4231 4131 4231 4.876289e+00
R_4231_4331 4231 4331 2.314308e+00
R_4331_4431 4331 4431 9.044088e+00
R_4431_4531 4431 4531 1.906728e+00
R_4531_4631 4531 4631 8.851477e+00
R_4631_4731 4631 4731 7.289044e+00
R_4731_4831 4731 4831 2.761557e+00
R_4831_4931 4831 4931 9.781027e+00
R_4931_5031 4931 5031 1.363183e+00
R_5031_5131 5031 5131 4.033169e+00
R_5131_5231 5131 5231 4.436420e+00
R_5231_5331 5231 5331 3.454370e+00
R_5331_5431 5331 5431 8.995317e+00
R_5431_5531 5431 5531 3.612760e+00
R_5531_5631 5531 5631 2.802579e+00
R_5631_5731 5631 5731 9.454145e+00
R_5731_5831 5731 5831 6.491252e+00
R_5831_5931 5831 5931 8.752070e+00
R_5931_6031 5931 6031 3.354401e+00
R_6031_6131 6031 6131 9.015907e+00
R_6131_6231 6131 6231 2.704646e-01
R_6231_6331 6231 6331 2.817110e+00
R_6331_6431 6331 6431 6.934200e+00
R_6431_6531 6431 6531 5.782757e-01
R_6531_6631 6531 6631 4.030545e+00
R_6631_6731 6631 6731 9.584382e+00
R_6731_6831 6731 6831 1.571056e+00
R_6831_6931 6831 6931 8.436879e+00
R_6931_7031 6931 7031 2.552534e-01
R_7031_7131 7031 7131 4.755764e+00
R_7131_7231 7131 7231 4.538327e+00
R_7231_7331 7231 7331 6.729552e-03
R_7331_7431 7331 7431 4.016040e-01
R_7431_7531 7431 7531 7.448260e+00
R_7531_7631 7531 7631 4.819569e+00
R_7631_7731 7631 7731 1.641070e+00
R_7731_7831 7731 7831 1.916101e+00
R_7831_7931 7831 7931 4.596216e+00
R_7931_8031 7931 8031 8.494446e+00
R_8031_8131 8031 8131 2.667988e+00
R_8131_8231 8131 8231 1.128156e+00
R_8231_8331 8231 8331 4.235273e+00
R_8331_8431 8331 8431 3.658293e+00
R_8431_8531 8431 8531 1.282562e+00
R_8531_8631 8531 8631 1.838562e+00
R_8631_8731 8631 8731 1.001713e+00
R_8731_8831 8731 8831 4.746934e+00
R_8831_8931 8831 8931 2.817450e+00
R_8931_9031 8931 9031 4.658786e+00
R_9031_9131 9031 9131 3.102848e+00
R_9131_9231 9131 9231 9.025178e+00
R_9231_9331 9231 9331 7.998880e+00
R_9331_9431 9331 9431 2.528833e+00
R_9431_9531 9431 9531 7.453052e+00
R_9531_9631 9531 9631 7.320012e+00
R_9631_9731 9631 9731 1.234390e+00
R_9731_9831 9731 9831 7.799686e+00
R_9831_9931 9831 9931 7.648334e+00
R_32_132 32 132 6.953615e+00
R_132_232 132 232 3.967338e+00
R_232_332 232 332 3.561651e+00
R_332_432 332 432 7.631375e+00
R_432_532 432 532 4.587121e+00
R_532_632 532 632 6.884081e-01
R_632_732 632 732 5.041309e+00
R_732_832 732 832 1.269269e+00
R_832_932 832 932 8.856795e+00
R_932_1032 932 1032 9.645745e+00
R_1032_1132 1032 1132 5.727783e+00
R_1132_1232 1132 1232 2.955886e+00
R_1232_1332 1232 1332 9.529516e-01
R_1332_1432 1332 1432 2.598333e+00
R_1432_1532 1432 1532 2.455981e+00
R_1532_1632 1532 1632 5.647194e+00
R_1632_1732 1632 1732 3.801976e+00
R_1732_1832 1732 1832 9.567458e-01
R_1832_1932 1832 1932 1.613245e+00
R_1932_2032 1932 2032 8.806320e+00
R_2032_2132 2032 2132 6.262093e+00
R_2132_2232 2132 2232 3.264909e+00
R_2232_2332 2232 2332 6.361325e+00
R_2332_2432 2332 2432 5.695629e+00
R_2432_2532 2432 2532 1.516389e+00
R_2532_2632 2532 2632 1.533236e+00
R_2632_2732 2632 2732 8.341056e+00
R_2732_2832 2732 2832 9.733396e+00
R_2832_2932 2832 2932 7.891706e+00
R_2932_3032 2932 3032 9.503031e+00
R_3032_3132 3032 3132 2.096171e-01
R_3132_3232 3132 3232 2.951234e-01
R_3232_3332 3232 3332 7.232778e+00
R_3332_3432 3332 3432 7.626987e+00
R_3432_3532 3432 3532 8.994573e-01
R_3532_3632 3532 3632 6.064134e+00
R_3632_3732 3632 3732 9.470710e+00
R_3732_3832 3732 3832 9.175316e-01
R_3832_3932 3832 3932 8.910415e+00
R_3932_4032 3932 4032 7.722661e-01
R_4032_4132 4032 4132 1.041643e+00
R_4132_4232 4132 4232 3.212608e+00
R_4232_4332 4232 4332 4.148184e+00
R_4332_4432 4332 4432 4.975266e+00
R_4432_4532 4432 4532 6.746384e+00
R_4532_4632 4532 4632 1.947472e+00
R_4632_4732 4632 4732 3.473303e+00
R_4732_4832 4732 4832 7.139666e+00
R_4832_4932 4832 4932 9.104214e+00
R_4932_5032 4932 5032 6.861259e+00
R_5032_5132 5032 5132 2.753846e+00
R_5132_5232 5132 5232 1.602548e+00
R_5232_5332 5232 5332 2.763080e+00
R_5332_5432 5332 5432 2.476693e+00
R_5432_5532 5432 5532 8.609180e+00
R_5532_5632 5532 5632 6.089832e+00
R_5632_5732 5632 5732 7.276429e+00
R_5732_5832 5732 5832 6.695196e+00
R_5832_5932 5832 5932 4.618709e+00
R_5932_6032 5932 6032 4.444336e+00
R_6032_6132 6032 6132 9.640690e-01
R_6132_6232 6132 6232 7.791707e+00
R_6232_6332 6232 6332 6.280349e-01
R_6332_6432 6332 6432 6.103130e-01
R_6432_6532 6432 6532 5.497605e+00
R_6532_6632 6532 6632 9.313760e+00
R_6632_6732 6632 6732 3.506847e+00
R_6732_6832 6732 6832 1.201200e-01
R_6832_6932 6832 6932 2.995884e+00
R_6932_7032 6932 7032 7.726401e-01
R_7032_7132 7032 7132 5.572687e+00
R_7132_7232 7132 7232 2.373154e-01
R_7232_7332 7232 7332 4.144825e+00
R_7332_7432 7332 7432 3.925989e+00
R_7432_7532 7432 7532 9.511177e+00
R_7532_7632 7532 7632 2.669743e+00
R_7632_7732 7632 7732 8.010393e+00
R_7732_7832 7732 7832 9.488626e+00
R_7832_7932 7832 7932 3.387162e+00
R_7932_8032 7932 8032 5.488070e+00
R_8032_8132 8032 8132 2.623974e+00
R_8132_8232 8132 8232 9.986513e+00
R_8232_8332 8232 8332 8.864236e+00
R_8332_8432 8332 8432 4.884179e-01
R_8432_8532 8432 8532 3.817419e+00
R_8532_8632 8532 8632 7.164791e+00
R_8632_8732 8632 8732 2.987863e+00
R_8732_8832 8732 8832 6.102271e+00
R_8832_8932 8832 8932 7.948491e+00
R_8932_9032 8932 9032 8.018012e+00
R_9032_9132 9032 9132 7.216613e+00
R_9132_9232 9132 9232 5.271618e+00
R_9232_9332 9232 9332 4.399135e-01
R_9332_9432 9332 9432 2.188643e+00
R_9432_9532 9432 9532 8.480745e+00
R_9532_9632 9532 9632 5.416381e+00
R_9632_9732 9632 9732 2.948655e+00
R_9732_9832 9732 9832 3.887793e+00
R_9832_9932 9832 9932 2.068383e+00
R_33_133 33 133 2.057184e+00
R_133_233 133 233 5.567151e+00
R_233_333 233 333 9.215417e-01
R_333_433 333 433 8.525968e+00
R_433_533 433 533 8.581030e+00
R_533_633 533 633 6.443145e+00
R_633_733 633 733 4.765818e+00
R_733_833 733 833 9.641148e+00
R_833_933 833 933 3.737062e+00
R_933_1033 933 1033 5.801699e+00
R_1033_1133 1033 1133 5.317120e+00
R_1133_1233 1133 1233 3.056818e-01
R_1233_1333 1233 1333 6.024519e+00
R_1333_1433 1333 1433 2.609794e+00
R_1433_1533 1433 1533 7.866278e+00
R_1533_1633 1533 1633 5.025338e+00
R_1633_1733 1633 1733 4.056230e+00
R_1733_1833 1733 1833 8.364621e+00
R_1833_1933 1833 1933 1.432616e+00
R_1933_2033 1933 2033 9.141283e-01
R_2033_2133 2033 2133 4.409413e+00
R_2133_2233 2133 2233 4.715366e+00
R_2233_2333 2233 2333 3.496361e+00
R_2333_2433 2333 2433 8.055082e+00
R_2433_2533 2433 2533 4.764520e+00
R_2533_2633 2533 2633 1.538847e+00
R_2633_2733 2633 2733 9.192435e+00
R_2733_2833 2733 2833 1.128765e+00
R_2833_2933 2833 2933 4.280166e+00
R_2933_3033 2933 3033 3.910795e+00
R_3033_3133 3033 3133 6.921554e+00
R_3133_3233 3133 3233 2.667188e+00
R_3233_3333 3233 3333 4.259331e-01
R_3333_3433 3333 3433 1.232286e+00
R_3433_3533 3433 3533 1.212151e+00
R_3533_3633 3533 3633 8.837471e+00
R_3633_3733 3633 3733 1.783881e+00
R_3733_3833 3733 3833 5.732611e+00
R_3833_3933 3833 3933 7.621846e+00
R_3933_4033 3933 4033 3.080261e+00
R_4033_4133 4033 4133 9.125722e+00
R_4133_4233 4133 4233 5.866172e+00
R_4233_4333 4233 4333 1.240401e+00
R_4333_4433 4333 4433 5.532466e+00
R_4433_4533 4433 4533 9.793612e+00
R_4533_4633 4533 4633 1.247715e+00
R_4633_4733 4633 4733 4.435041e+00
R_4733_4833 4733 4833 6.382642e+00
R_4833_4933 4833 4933 1.248023e+00
R_4933_5033 4933 5033 5.751346e+00
R_5033_5133 5033 5133 3.432967e+00
R_5133_5233 5133 5233 2.554642e+00
R_5233_5333 5233 5333 9.473659e+00
R_5333_5433 5333 5433 3.153802e+00
R_5433_5533 5433 5533 1.859886e-01
R_5533_5633 5533 5633 7.863639e-01
R_5633_5733 5633 5733 6.063613e+00
R_5733_5833 5733 5833 8.083976e+00
R_5833_5933 5833 5933 2.047364e-01
R_5933_6033 5933 6033 8.751188e+00
R_6033_6133 6033 6133 3.028183e-01
R_6133_6233 6133 6233 1.814701e+00
R_6233_6333 6233 6333 6.955703e+00
R_6333_6433 6333 6433 2.657088e+00
R_6433_6533 6433 6533 3.265622e+00
R_6533_6633 6533 6633 1.713077e+00
R_6633_6733 6633 6733 1.631175e+00
R_6733_6833 6733 6833 2.970392e+00
R_6833_6933 6833 6933 9.053318e+00
R_6933_7033 6933 7033 3.766183e+00
R_7033_7133 7033 7133 4.078073e-01
R_7133_7233 7133 7233 9.976896e+00
R_7233_7333 7233 7333 6.394891e+00
R_7333_7433 7333 7433 4.694499e+00
R_7433_7533 7433 7533 4.415806e+00
R_7533_7633 7533 7633 7.170299e+00
R_7633_7733 7633 7733 8.411121e+00
R_7733_7833 7733 7833 9.038505e-01
R_7833_7933 7833 7933 6.847096e-01
R_7933_8033 7933 8033 6.734983e+00
R_8033_8133 8033 8133 1.872012e+00
R_8133_8233 8133 8233 5.320734e+00
R_8233_8333 8233 8333 5.233109e+00
R_8333_8433 8333 8433 3.821999e+00
R_8433_8533 8433 8533 9.666261e+00
R_8533_8633 8533 8633 2.505866e+00
R_8633_8733 8633 8733 3.880908e+00
R_8733_8833 8733 8833 6.358783e+00
R_8833_8933 8833 8933 4.414522e+00
R_8933_9033 8933 9033 1.248229e+00
R_9033_9133 9033 9133 3.211619e+00
R_9133_9233 9133 9233 3.159103e+00
R_9233_9333 9233 9333 9.107996e+00
R_9333_9433 9333 9433 4.337022e+00
R_9433_9533 9433 9533 4.192157e+00
R_9533_9633 9533 9633 7.567375e-01
R_9633_9733 9633 9733 5.879585e+00
R_9733_9833 9733 9833 5.842394e+00
R_9833_9933 9833 9933 9.135054e+00
R_34_134 34 134 9.613058e+00
R_134_234 134 234 4.517882e+00
R_234_334 234 334 6.756498e+00
R_334_434 334 434 2.400092e+00
R_434_534 434 534 3.648131e+00
R_534_634 534 634 5.100070e+00
R_634_734 634 734 8.735050e+00
R_734_834 734 834 9.097745e+00
R_834_934 834 934 5.449030e+00
R_934_1034 934 1034 2.853854e+00
R_1034_1134 1034 1134 5.802119e+00
R_1134_1234 1134 1234 9.531197e+00
R_1234_1334 1234 1334 8.200341e+00
R_1334_1434 1334 1434 9.785924e+00
R_1434_1534 1434 1534 2.923239e+00
R_1534_1634 1534 1634 4.432615e+00
R_1634_1734 1634 1734 5.194117e+00
R_1734_1834 1734 1834 7.200110e+00
R_1834_1934 1834 1934 4.690612e+00
R_1934_2034 1934 2034 4.880132e+00
R_2034_2134 2034 2134 9.459810e+00
R_2134_2234 2134 2234 5.892895e-02
R_2234_2334 2234 2334 4.617559e+00
R_2334_2434 2334 2434 2.257458e+00
R_2434_2534 2434 2534 1.727067e+00
R_2534_2634 2534 2634 3.878975e+00
R_2634_2734 2634 2734 2.968362e-01
R_2734_2834 2734 2834 1.308110e+00
R_2834_2934 2834 2934 9.575289e+00
R_2934_3034 2934 3034 3.357229e+00
R_3034_3134 3034 3134 8.007636e+00
R_3134_3234 3134 3234 5.668488e+00
R_3234_3334 3234 3334 6.983560e+00
R_3334_3434 3334 3434 8.420195e+00
R_3434_3534 3434 3534 4.779133e+00
R_3534_3634 3534 3634 1.313663e+00
R_3634_3734 3634 3734 7.865577e+00
R_3734_3834 3734 3834 8.005761e+00
R_3834_3934 3834 3934 3.391855e+00
R_3934_4034 3934 4034 6.372314e+00
R_4034_4134 4034 4134 1.216323e+00
R_4134_4234 4134 4234 2.277590e-01
R_4234_4334 4234 4334 9.081508e+00
R_4334_4434 4334 4434 7.391824e-02
R_4434_4534 4434 4534 1.470028e+00
R_4534_4634 4534 4634 1.213753e+00
R_4634_4734 4634 4734 4.151837e+00
R_4734_4834 4734 4834 4.994845e+00
R_4834_4934 4834 4934 9.151137e+00
R_4934_5034 4934 5034 9.929588e+00
R_5034_5134 5034 5134 1.127395e+00
R_5134_5234 5134 5234 7.892357e-02
R_5234_5334 5234 5334 9.786232e+00
R_5334_5434 5334 5434 4.686510e+00
R_5434_5534 5434 5534 8.849061e+00
R_5534_5634 5534 5634 6.057713e+00
R_5634_5734 5634 5734 4.188362e+00
R_5734_5834 5734 5834 2.066424e+00
R_5834_5934 5834 5934 4.705579e+00
R_5934_6034 5934 6034 2.185529e+00
R_6034_6134 6034 6134 2.341133e-01
R_6134_6234 6134 6234 2.920743e+00
R_6234_6334 6234 6334 5.698769e+00
R_6334_6434 6334 6434 3.690333e+00
R_6434_6534 6434 6534 1.997526e+00
R_6534_6634 6534 6634 2.342544e+00
R_6634_6734 6634 6734 2.748374e+00
R_6734_6834 6734 6834 7.497203e+00
R_6834_6934 6834 6934 1.891612e+00
R_6934_7034 6934 7034 3.791852e+00
R_7034_7134 7034 7134 1.658540e+00
R_7134_7234 7134 7234 4.692956e-01
R_7234_7334 7234 7334 8.939188e+00
R_7334_7434 7334 7434 3.445190e-01
R_7434_7534 7434 7534 3.830579e+00
R_7534_7634 7534 7634 1.946273e+00
R_7634_7734 7634 7734 7.926894e+00
R_7734_7834 7734 7834 7.659502e+00
R_7834_7934 7834 7934 7.528460e+00
R_7934_8034 7934 8034 7.973763e+00
R_8034_8134 8034 8134 5.088800e+00
R_8134_8234 8134 8234 7.102846e+00
R_8234_8334 8234 8334 8.983932e+00
R_8334_8434 8334 8434 8.689406e+00
R_8434_8534 8434 8534 2.589263e+00
R_8534_8634 8534 8634 4.160395e+00
R_8634_8734 8634 8734 9.734358e+00
R_8734_8834 8734 8834 5.409203e+00
R_8834_8934 8834 8934 2.092231e+00
R_8934_9034 8934 9034 5.098435e+00
R_9034_9134 9034 9134 7.530922e+00
R_9134_9234 9134 9234 7.847671e+00
R_9234_9334 9234 9334 2.043612e-01
R_9334_9434 9334 9434 7.929826e+00
R_9434_9534 9434 9534 7.242407e+00
R_9534_9634 9534 9634 2.050052e-01
R_9634_9734 9634 9734 5.630849e+00
R_9734_9834 9734 9834 1.582134e+00
R_9834_9934 9834 9934 9.341461e+00
R_35_135 35 135 7.299263e+00
R_135_235 135 235 7.587720e+00
R_235_335 235 335 3.502310e+00
R_335_435 335 435 6.497253e+00
R_435_535 435 535 8.536998e+00
R_535_635 535 635 5.881970e+00
R_635_735 635 735 2.521884e+00
R_735_835 735 835 3.135370e+00
R_835_935 835 935 4.124509e+00
R_935_1035 935 1035 7.532780e+00
R_1035_1135 1035 1135 6.382003e+00
R_1135_1235 1135 1235 6.546565e+00
R_1235_1335 1235 1335 2.417650e+00
R_1335_1435 1335 1435 5.471132e+00
R_1435_1535 1435 1535 3.287032e+00
R_1535_1635 1535 1635 5.823764e+00
R_1635_1735 1635 1735 9.752873e+00
R_1735_1835 1735 1835 2.847496e+00
R_1835_1935 1835 1935 8.687806e+00
R_1935_2035 1935 2035 3.184197e+00
R_2035_2135 2035 2135 9.569365e+00
R_2135_2235 2135 2235 8.950021e+00
R_2235_2335 2235 2335 4.466294e+00
R_2335_2435 2335 2435 6.655901e+00
R_2435_2535 2435 2535 6.421230e+00
R_2535_2635 2535 2635 5.425398e+00
R_2635_2735 2635 2735 7.260777e+00
R_2735_2835 2735 2835 8.882467e+00
R_2835_2935 2835 2935 1.342763e-01
R_2935_3035 2935 3035 1.071646e+00
R_3035_3135 3035 3135 8.710265e+00
R_3135_3235 3135 3235 7.270667e+00
R_3235_3335 3235 3335 2.724664e+00
R_3335_3435 3335 3435 7.034148e+00
R_3435_3535 3435 3535 9.186690e+00
R_3535_3635 3535 3635 3.802709e-02
R_3635_3735 3635 3735 3.465599e+00
R_3735_3835 3735 3835 8.396788e+00
R_3835_3935 3835 3935 1.299034e+00
R_3935_4035 3935 4035 2.589370e+00
R_4035_4135 4035 4135 7.632528e+00
R_4135_4235 4135 4235 9.439759e+00
R_4235_4335 4235 4335 7.980902e+00
R_4335_4435 4335 4435 3.093081e+00
R_4435_4535 4435 4535 7.921383e+00
R_4535_4635 4535 4635 7.817040e+00
R_4635_4735 4635 4735 1.509491e+00
R_4735_4835 4735 4835 6.316742e+00
R_4835_4935 4835 4935 2.777846e+00
R_4935_5035 4935 5035 8.207229e+00
R_5035_5135 5035 5135 6.210185e+00
R_5135_5235 5135 5235 9.694890e+00
R_5235_5335 5235 5335 2.513439e+00
R_5335_5435 5335 5435 4.068330e+00
R_5435_5535 5435 5535 8.039678e+00
R_5535_5635 5535 5635 4.865334e+00
R_5635_5735 5635 5735 4.313719e+00
R_5735_5835 5735 5835 8.135847e+00
R_5835_5935 5835 5935 5.333725e+00
R_5935_6035 5935 6035 5.450210e+00
R_6035_6135 6035 6135 8.968860e+00
R_6135_6235 6135 6235 7.335880e+00
R_6235_6335 6235 6335 7.711114e+00
R_6335_6435 6335 6435 3.443953e+00
R_6435_6535 6435 6535 2.292362e+00
R_6535_6635 6535 6635 8.085036e+00
R_6635_6735 6635 6735 3.976277e+00
R_6735_6835 6735 6835 1.729575e+00
R_6835_6935 6835 6935 5.666908e-01
R_6935_7035 6935 7035 4.667713e-01
R_7035_7135 7035 7135 3.627604e-02
R_7135_7235 7135 7235 6.480613e+00
R_7235_7335 7235 7335 6.264531e+00
R_7335_7435 7335 7435 3.302101e+00
R_7435_7535 7435 7535 8.345159e+00
R_7535_7635 7535 7635 4.010345e+00
R_7635_7735 7635 7735 4.850782e+00
R_7735_7835 7735 7835 5.937874e+00
R_7835_7935 7835 7935 8.892383e+00
R_7935_8035 7935 8035 1.413558e+00
R_8035_8135 8035 8135 5.753185e+00
R_8135_8235 8135 8235 1.257180e+00
R_8235_8335 8235 8335 6.152258e+00
R_8335_8435 8335 8435 6.385546e+00
R_8435_8535 8435 8535 2.938322e+00
R_8535_8635 8535 8635 8.022760e+00
R_8635_8735 8635 8735 9.051024e+00
R_8735_8835 8735 8835 5.441572e+00
R_8835_8935 8835 8935 3.506324e+00
R_8935_9035 8935 9035 9.450661e+00
R_9035_9135 9035 9135 6.944719e+00
R_9135_9235 9135 9235 6.495954e+00
R_9235_9335 9235 9335 5.346301e+00
R_9335_9435 9335 9435 5.499423e+00
R_9435_9535 9435 9535 2.471174e+00
R_9535_9635 9535 9635 4.068959e+00
R_9635_9735 9635 9735 2.711194e+00
R_9735_9835 9735 9835 7.843180e+00
R_9835_9935 9835 9935 9.262697e+00
R_36_136 36 136 8.009737e+00
R_136_236 136 236 4.907481e+00
R_236_336 236 336 3.376919e+00
R_336_436 336 436 7.300648e+00
R_436_536 436 536 1.285858e+00
R_536_636 536 636 2.270477e+00
R_636_736 636 736 7.340712e+00
R_736_836 736 836 8.686867e+00
R_836_936 836 936 9.246751e+00
R_936_1036 936 1036 4.223545e+00
R_1036_1136 1036 1136 9.254677e+00
R_1136_1236 1136 1236 4.582553e+00
R_1236_1336 1236 1336 7.444317e+00
R_1336_1436 1336 1436 4.150499e+00
R_1436_1536 1436 1536 8.953372e-01
R_1536_1636 1536 1636 3.902737e+00
R_1636_1736 1636 1736 5.203515e+00
R_1736_1836 1736 1836 2.609998e+00
R_1836_1936 1836 1936 8.101696e-01
R_1936_2036 1936 2036 3.511493e+00
R_2036_2136 2036 2136 3.612162e+00
R_2136_2236 2136 2236 4.264347e+00
R_2236_2336 2236 2336 2.131136e+00
R_2336_2436 2336 2436 6.237029e-01
R_2436_2536 2436 2536 7.577800e+00
R_2536_2636 2536 2636 3.552815e-01
R_2636_2736 2636 2736 6.681630e+00
R_2736_2836 2736 2836 6.475670e+00
R_2836_2936 2836 2936 8.540081e+00
R_2936_3036 2936 3036 7.630642e+00
R_3036_3136 3036 3136 6.704803e+00
R_3136_3236 3136 3236 8.983655e+00
R_3236_3336 3236 3336 8.015973e+00
R_3336_3436 3336 3436 3.057824e+00
R_3436_3536 3436 3536 7.793821e+00
R_3536_3636 3536 3636 6.453933e+00
R_3636_3736 3636 3736 1.989417e+00
R_3736_3836 3736 3836 4.401990e+00
R_3836_3936 3836 3936 2.483195e+00
R_3936_4036 3936 4036 6.034020e-01
R_4036_4136 4036 4136 8.880906e+00
R_4136_4236 4136 4236 7.085932e+00
R_4236_4336 4236 4336 4.223873e+00
R_4336_4436 4336 4436 5.421919e+00
R_4436_4536 4436 4536 8.866522e+00
R_4536_4636 4536 4636 1.942809e+00
R_4636_4736 4636 4736 6.950778e+00
R_4736_4836 4736 4836 2.804559e+00
R_4836_4936 4836 4936 1.212388e+00
R_4936_5036 4936 5036 7.226660e+00
R_5036_5136 5036 5136 6.986683e+00
R_5136_5236 5136 5236 6.323226e+00
R_5236_5336 5236 5336 8.030573e+00
R_5336_5436 5336 5436 6.723892e+00
R_5436_5536 5436 5536 9.478858e+00
R_5536_5636 5536 5636 5.468301e+00
R_5636_5736 5636 5736 4.350183e+00
R_5736_5836 5736 5836 8.122307e+00
R_5836_5936 5836 5936 7.875762e+00
R_5936_6036 5936 6036 9.362927e+00
R_6036_6136 6036 6136 1.662749e+00
R_6136_6236 6136 6236 2.818688e+00
R_6236_6336 6236 6336 5.212473e+00
R_6336_6436 6336 6436 1.590302e+00
R_6436_6536 6436 6536 7.389446e+00
R_6536_6636 6536 6636 2.368142e+00
R_6636_6736 6636 6736 2.447675e+00
R_6736_6836 6736 6836 1.839023e+00
R_6836_6936 6836 6936 9.263676e+00
R_6936_7036 6936 7036 6.192857e-01
R_7036_7136 7036 7136 5.330973e+00
R_7136_7236 7136 7236 9.038266e+00
R_7236_7336 7236 7336 9.791986e+00
R_7336_7436 7336 7436 1.323166e+00
R_7436_7536 7436 7536 7.962930e+00
R_7536_7636 7536 7636 3.067288e+00
R_7636_7736 7636 7736 4.528731e+00
R_7736_7836 7736 7836 8.268207e+00
R_7836_7936 7836 7936 9.619016e+00
R_7936_8036 7936 8036 5.224245e+00
R_8036_8136 8036 8136 5.402081e+00
R_8136_8236 8136 8236 6.278947e-01
R_8236_8336 8236 8336 6.189793e+00
R_8336_8436 8336 8436 1.137895e+00
R_8436_8536 8436 8536 7.391298e+00
R_8536_8636 8536 8636 4.773831e+00
R_8636_8736 8636 8736 2.228202e+00
R_8736_8836 8736 8836 7.338784e+00
R_8836_8936 8836 8936 9.193564e+00
R_8936_9036 8936 9036 6.705248e+00
R_9036_9136 9036 9136 4.902736e+00
R_9136_9236 9136 9236 3.584138e+00
R_9236_9336 9236 9336 8.316293e+00
R_9336_9436 9336 9436 1.287783e+00
R_9436_9536 9436 9536 2.696662e-01
R_9536_9636 9536 9636 4.131499e+00
R_9636_9736 9636 9736 3.753127e+00
R_9736_9836 9736 9836 3.079912e+00
R_9836_9936 9836 9936 8.287302e+00
R_37_137 37 137 8.063072e+00
R_137_237 137 237 6.308638e+00
R_237_337 237 337 4.440769e+00
R_337_437 337 437 6.475612e+00
R_437_537 437 537 8.313247e+00
R_537_637 537 637 1.996134e+00
R_637_737 637 737 4.586955e+00
R_737_837 737 837 9.585201e-01
R_837_937 837 937 8.362325e+00
R_937_1037 937 1037 3.808325e+00
R_1037_1137 1037 1137 2.005232e+00
R_1137_1237 1137 1237 5.432464e+00
R_1237_1337 1237 1337 7.084801e+00
R_1337_1437 1337 1437 4.043647e+00
R_1437_1537 1437 1537 9.290336e+00
R_1537_1637 1537 1637 9.042668e+00
R_1637_1737 1637 1737 2.069670e+00
R_1737_1837 1737 1837 3.700324e+00
R_1837_1937 1837 1937 4.720409e+00
R_1937_2037 1937 2037 9.047173e+00
R_2037_2137 2037 2137 4.079059e+00
R_2137_2237 2137 2237 1.271516e+00
R_2237_2337 2237 2337 7.392552e-01
R_2337_2437 2337 2437 2.494431e+00
R_2437_2537 2437 2537 4.857628e+00
R_2537_2637 2537 2637 2.478101e+00
R_2637_2737 2637 2737 3.830005e+00
R_2737_2837 2737 2837 5.145287e+00
R_2837_2937 2837 2937 7.233873e+00
R_2937_3037 2937 3037 7.890872e+00
R_3037_3137 3037 3137 7.424787e+00
R_3137_3237 3137 3237 2.403460e+00
R_3237_3337 3237 3337 4.056472e+00
R_3337_3437 3337 3437 1.073096e-01
R_3437_3537 3437 3537 7.247300e+00
R_3537_3637 3537 3637 4.767427e-01
R_3637_3737 3637 3737 1.564646e+00
R_3737_3837 3737 3837 7.839829e+00
R_3837_3937 3837 3937 1.614182e+00
R_3937_4037 3937 4037 7.083498e+00
R_4037_4137 4037 4137 9.145656e+00
R_4137_4237 4137 4237 6.725948e+00
R_4237_4337 4237 4337 9.618002e+00
R_4337_4437 4337 4437 3.199976e-02
R_4437_4537 4437 4537 7.667712e+00
R_4537_4637 4537 4637 5.831130e+00
R_4637_4737 4637 4737 4.805626e+00
R_4737_4837 4737 4837 8.955075e+00
R_4837_4937 4837 4937 5.637819e+00
R_4937_5037 4937 5037 3.085035e+00
R_5037_5137 5037 5137 6.726717e-01
R_5137_5237 5137 5237 1.540899e+00
R_5237_5337 5237 5337 4.516991e+00
R_5337_5437 5337 5437 1.481681e+00
R_5437_5537 5437 5537 5.170282e+00
R_5537_5637 5537 5637 5.864103e+00
R_5637_5737 5637 5737 8.378022e+00
R_5737_5837 5737 5837 6.642875e+00
R_5837_5937 5837 5937 8.472990e+00
R_5937_6037 5937 6037 1.389242e-01
R_6037_6137 6037 6137 3.809820e+00
R_6137_6237 6137 6237 1.207169e+00
R_6237_6337 6237 6337 1.379021e+00
R_6337_6437 6337 6437 2.254476e+00
R_6437_6537 6437 6537 6.458535e+00
R_6537_6637 6537 6637 5.720734e+00
R_6637_6737 6637 6737 3.396353e+00
R_6737_6837 6737 6837 2.622389e-02
R_6837_6937 6837 6937 1.179691e+00
R_6937_7037 6937 7037 9.673603e+00
R_7037_7137 7037 7137 7.640020e+00
R_7137_7237 7137 7237 7.168649e+00
R_7237_7337 7237 7337 5.230746e+00
R_7337_7437 7337 7437 6.481652e+00
R_7437_7537 7437 7537 9.677659e+00
R_7537_7637 7537 7637 7.863575e+00
R_7637_7737 7637 7737 7.625299e+00
R_7737_7837 7737 7837 4.794016e+00
R_7837_7937 7837 7937 1.200369e+00
R_7937_8037 7937 8037 2.563178e+00
R_8037_8137 8037 8137 8.226715e+00
R_8137_8237 8137 8237 2.192943e-01
R_8237_8337 8237 8337 6.619835e+00
R_8337_8437 8337 8437 3.325510e+00
R_8437_8537 8437 8537 2.353793e+00
R_8537_8637 8537 8637 4.911701e+00
R_8637_8737 8637 8737 6.946274e+00
R_8737_8837 8737 8837 5.536413e+00
R_8837_8937 8837 8937 4.604382e+00
R_8937_9037 8937 9037 3.155441e+00
R_9037_9137 9037 9137 9.384016e+00
R_9137_9237 9137 9237 6.132480e+00
R_9237_9337 9237 9337 3.844332e-01
R_9337_9437 9337 9437 6.873093e-01
R_9437_9537 9437 9537 6.540975e+00
R_9537_9637 9537 9637 4.608610e+00
R_9637_9737 9637 9737 1.565431e+00
R_9737_9837 9737 9837 5.052615e+00
R_9837_9937 9837 9937 2.027006e+00
R_38_138 38 138 6.670315e+00
R_138_238 138 238 7.737781e+00
R_238_338 238 338 7.442083e+00
R_338_438 338 438 6.074096e+00
R_438_538 438 538 9.533331e-01
R_538_638 538 638 6.459869e+00
R_638_738 638 738 2.449668e+00
R_738_838 738 838 6.190783e+00
R_838_938 838 938 3.943308e+00
R_938_1038 938 1038 2.835564e+00
R_1038_1138 1038 1138 7.961637e+00
R_1138_1238 1138 1238 2.681217e+00
R_1238_1338 1238 1338 8.275630e+00
R_1338_1438 1338 1438 4.865320e+00
R_1438_1538 1438 1538 4.756637e+00
R_1538_1638 1538 1638 9.368133e+00
R_1638_1738 1638 1738 4.923486e+00
R_1738_1838 1738 1838 8.755777e+00
R_1838_1938 1838 1938 9.067911e-02
R_1938_2038 1938 2038 1.957410e+00
R_2038_2138 2038 2138 3.181109e+00
R_2138_2238 2138 2238 4.346927e+00
R_2238_2338 2238 2338 2.987950e-01
R_2338_2438 2338 2438 9.689210e+00
R_2438_2538 2438 2538 9.391233e+00
R_2538_2638 2538 2638 2.071856e+00
R_2638_2738 2638 2738 1.604495e+00
R_2738_2838 2738 2838 1.995343e+00
R_2838_2938 2838 2938 6.865971e+00
R_2938_3038 2938 3038 5.422609e+00
R_3038_3138 3038 3138 7.819955e+00
R_3138_3238 3138 3238 7.776551e+00
R_3238_3338 3238 3338 1.587301e+00
R_3338_3438 3338 3438 2.655181e+00
R_3438_3538 3438 3538 7.164171e+00
R_3538_3638 3538 3638 3.280765e+00
R_3638_3738 3638 3738 7.372251e+00
R_3738_3838 3738 3838 1.813373e+00
R_3838_3938 3838 3938 8.288727e+00
R_3938_4038 3938 4038 1.718858e+00
R_4038_4138 4038 4138 5.635751e-02
R_4138_4238 4138 4238 9.260457e+00
R_4238_4338 4238 4338 4.564877e+00
R_4338_4438 4338 4438 8.043889e+00
R_4438_4538 4438 4538 9.291201e+00
R_4538_4638 4538 4638 7.560870e+00
R_4638_4738 4638 4738 7.456946e+00
R_4738_4838 4738 4838 2.897492e-01
R_4838_4938 4838 4938 8.636370e+00
R_4938_5038 4938 5038 9.214335e+00
R_5038_5138 5038 5138 2.423284e+00
R_5138_5238 5138 5238 5.062984e+00
R_5238_5338 5238 5338 4.237413e+00
R_5338_5438 5338 5438 6.649660e+00
R_5438_5538 5438 5538 2.326514e+00
R_5538_5638 5538 5638 7.257684e-01
R_5638_5738 5638 5738 2.487130e+00
R_5738_5838 5738 5838 3.342355e+00
R_5838_5938 5838 5938 1.147146e-01
R_5938_6038 5938 6038 3.289348e+00
R_6038_6138 6038 6138 8.527382e+00
R_6138_6238 6138 6238 2.193478e+00
R_6238_6338 6238 6338 9.160308e-01
R_6338_6438 6338 6438 2.788943e+00
R_6438_6538 6438 6538 7.202616e+00
R_6538_6638 6538 6638 7.019192e+00
R_6638_6738 6638 6738 4.555459e+00
R_6738_6838 6738 6838 9.336873e+00
R_6838_6938 6838 6938 4.449787e+00
R_6938_7038 6938 7038 1.527502e+00
R_7038_7138 7038 7138 9.305500e+00
R_7138_7238 7138 7238 1.570854e+00
R_7238_7338 7238 7338 9.173724e+00
R_7338_7438 7338 7438 9.455443e+00
R_7438_7538 7438 7538 1.923957e+00
R_7538_7638 7538 7638 2.055439e+00
R_7638_7738 7638 7738 1.094592e+00
R_7738_7838 7738 7838 7.399966e+00
R_7838_7938 7838 7938 2.324170e+00
R_7938_8038 7938 8038 6.990968e+00
R_8038_8138 8038 8138 7.352058e+00
R_8138_8238 8138 8238 8.597393e+00
R_8238_8338 8238 8338 1.324018e+00
R_8338_8438 8338 8438 9.833127e+00
R_8438_8538 8438 8538 2.177916e+00
R_8538_8638 8538 8638 3.629220e+00
R_8638_8738 8638 8738 9.364280e+00
R_8738_8838 8738 8838 6.360474e+00
R_8838_8938 8838 8938 6.592732e+00
R_8938_9038 8938 9038 1.728192e+00
R_9038_9138 9038 9138 3.823001e+00
R_9138_9238 9138 9238 9.451565e+00
R_9238_9338 9238 9338 1.271288e+00
R_9338_9438 9338 9438 8.472399e+00
R_9438_9538 9438 9538 7.261626e+00
R_9538_9638 9538 9638 7.414426e+00
R_9638_9738 9638 9738 3.671294e+00
R_9738_9838 9738 9838 4.555265e+00
R_9838_9938 9838 9938 7.249461e+00
R_39_139 39 139 3.523849e+00
R_139_239 139 239 1.722229e+00
R_239_339 239 339 6.363898e+00
R_339_439 339 439 6.620279e+00
R_439_539 439 539 2.664133e+00
R_539_639 539 639 4.477287e+00
R_639_739 639 739 8.704029e+00
R_739_839 739 839 1.056029e+00
R_839_939 839 939 1.139268e+00
R_939_1039 939 1039 8.583576e-01
R_1039_1139 1039 1139 5.204890e+00
R_1139_1239 1139 1239 9.606231e+00
R_1239_1339 1239 1339 5.944065e+00
R_1339_1439 1339 1439 6.300427e-02
R_1439_1539 1439 1539 8.698033e+00
R_1539_1639 1539 1639 1.409384e+00
R_1639_1739 1639 1739 5.963047e-01
R_1739_1839 1739 1839 7.719636e-01
R_1839_1939 1839 1939 2.804732e+00
R_1939_2039 1939 2039 9.277869e+00
R_2039_2139 2039 2139 8.967256e+00
R_2139_2239 2139 2239 9.521093e+00
R_2239_2339 2239 2339 3.219501e+00
R_2339_2439 2339 2439 4.994896e+00
R_2439_2539 2439 2539 6.586743e+00
R_2539_2639 2539 2639 2.073260e+00
R_2639_2739 2639 2739 6.955768e+00
R_2739_2839 2739 2839 4.718456e+00
R_2839_2939 2839 2939 8.644974e+00
R_2939_3039 2939 3039 3.684882e+00
R_3039_3139 3039 3139 5.065763e+00
R_3139_3239 3139 3239 8.733019e+00
R_3239_3339 3239 3339 6.872701e+00
R_3339_3439 3339 3439 1.671668e+00
R_3439_3539 3439 3539 5.806668e+00
R_3539_3639 3539 3639 7.065258e+00
R_3639_3739 3639 3739 4.396408e+00
R_3739_3839 3739 3839 4.332235e+00
R_3839_3939 3839 3939 1.640809e+00
R_3939_4039 3939 4039 3.866455e+00
R_4039_4139 4039 4139 1.175430e+00
R_4139_4239 4139 4239 1.252422e-01
R_4239_4339 4239 4339 4.217810e+00
R_4339_4439 4339 4439 9.615503e+00
R_4439_4539 4439 4539 9.074227e+00
R_4539_4639 4539 4639 8.819246e+00
R_4639_4739 4639 4739 2.484625e+00
R_4739_4839 4739 4839 6.443892e+00
R_4839_4939 4839 4939 1.666114e+00
R_4939_5039 4939 5039 7.875715e+00
R_5039_5139 5039 5139 4.308967e+00
R_5139_5239 5139 5239 1.029312e+00
R_5239_5339 5239 5339 8.796023e+00
R_5339_5439 5339 5439 8.925344e+00
R_5439_5539 5439 5539 2.795870e+00
R_5539_5639 5539 5639 9.003505e+00
R_5639_5739 5639 5739 2.161448e+00
R_5739_5839 5739 5839 2.646319e-01
R_5839_5939 5839 5939 2.520686e+00
R_5939_6039 5939 6039 2.557257e+00
R_6039_6139 6039 6139 5.839362e+00
R_6139_6239 6139 6239 7.661069e+00
R_6239_6339 6239 6339 9.728207e+00
R_6339_6439 6339 6439 9.647494e+00
R_6439_6539 6439 6539 1.272107e+00
R_6539_6639 6539 6639 5.702141e-01
R_6639_6739 6639 6739 3.902455e+00
R_6739_6839 6739 6839 3.499608e-01
R_6839_6939 6839 6939 8.599070e+00
R_6939_7039 6939 7039 4.862411e+00
R_7039_7139 7039 7139 1.914007e+00
R_7139_7239 7139 7239 8.736696e+00
R_7239_7339 7239 7339 3.603608e+00
R_7339_7439 7339 7439 7.437379e+00
R_7439_7539 7439 7539 9.044833e+00
R_7539_7639 7539 7639 5.540404e+00
R_7639_7739 7639 7739 9.299724e+00
R_7739_7839 7739 7839 1.139853e+00
R_7839_7939 7839 7939 9.556339e+00
R_7939_8039 7939 8039 9.175386e+00
R_8039_8139 8039 8139 9.608053e+00
R_8139_8239 8139 8239 7.747846e+00
R_8239_8339 8239 8339 4.684667e+00
R_8339_8439 8339 8439 9.495218e+00
R_8439_8539 8439 8539 4.544040e-01
R_8539_8639 8539 8639 2.732745e+00
R_8639_8739 8639 8739 3.008928e+00
R_8739_8839 8739 8839 9.475701e+00
R_8839_8939 8839 8939 6.618375e+00
R_8939_9039 8939 9039 4.851642e+00
R_9039_9139 9039 9139 6.322374e-01
R_9139_9239 9139 9239 9.903913e+00
R_9239_9339 9239 9339 7.265334e+00
R_9339_9439 9339 9439 4.903289e+00
R_9439_9539 9439 9539 2.701365e+00
R_9539_9639 9539 9639 7.017502e+00
R_9639_9739 9639 9739 4.154077e+00
R_9739_9839 9739 9839 8.521715e+00
R_9839_9939 9839 9939 3.239800e+00
R_40_140 40 140 9.746861e+00
R_140_240 140 240 4.801136e+00
R_240_340 240 340 6.928909e-01
R_340_440 340 440 1.782398e+00
R_440_540 440 540 7.450150e+00
R_540_640 540 640 4.670512e-01
R_640_740 640 740 7.447686e+00
R_740_840 740 840 8.739127e+00
R_840_940 840 940 4.414519e+00
R_940_1040 940 1040 1.305900e+00
R_1040_1140 1040 1140 5.461770e+00
R_1140_1240 1140 1240 8.225248e+00
R_1240_1340 1240 1340 8.494692e+00
R_1340_1440 1340 1440 1.650212e-01
R_1440_1540 1440 1540 9.749766e+00
R_1540_1640 1540 1640 2.933933e+00
R_1640_1740 1640 1740 4.395563e+00
R_1740_1840 1740 1840 4.685737e+00
R_1840_1940 1840 1940 2.710236e+00
R_1940_2040 1940 2040 7.750961e+00
R_2040_2140 2040 2140 2.218212e+00
R_2140_2240 2140 2240 8.882264e+00
R_2240_2340 2240 2340 3.195985e+00
R_2340_2440 2340 2440 9.710416e+00
R_2440_2540 2440 2540 2.627449e+00
R_2540_2640 2540 2640 8.576280e+00
R_2640_2740 2640 2740 9.290248e+00
R_2740_2840 2740 2840 3.603945e+00
R_2840_2940 2840 2940 2.940025e+00
R_2940_3040 2940 3040 4.783205e+00
R_3040_3140 3040 3140 8.040748e+00
R_3140_3240 3140 3240 6.615785e+00
R_3240_3340 3240 3340 9.671653e+00
R_3340_3440 3340 3440 4.525340e+00
R_3440_3540 3440 3540 4.694775e+00
R_3540_3640 3540 3640 3.719431e+00
R_3640_3740 3640 3740 1.847874e+00
R_3740_3840 3740 3840 3.394912e-02
R_3840_3940 3840 3940 5.205364e+00
R_3940_4040 3940 4040 7.651534e+00
R_4040_4140 4040 4140 8.285185e+00
R_4140_4240 4140 4240 8.938611e+00
R_4240_4340 4240 4340 2.356767e+00
R_4340_4440 4340 4440 7.668934e+00
R_4440_4540 4440 4540 3.580191e+00
R_4540_4640 4540 4640 3.178258e+00
R_4640_4740 4640 4740 8.599387e+00
R_4740_4840 4740 4840 7.226545e+00
R_4840_4940 4840 4940 9.634547e+00
R_4940_5040 4940 5040 5.712117e+00
R_5040_5140 5040 5140 4.975709e+00
R_5140_5240 5140 5240 9.421729e+00
R_5240_5340 5240 5340 8.160205e+00
R_5340_5440 5340 5440 1.245984e+00
R_5440_5540 5440 5540 3.807277e+00
R_5540_5640 5540 5640 7.898192e+00
R_5640_5740 5640 5740 8.833767e+00
R_5740_5840 5740 5840 8.170994e+00
R_5840_5940 5840 5940 9.782857e+00
R_5940_6040 5940 6040 2.333227e+00
R_6040_6140 6040 6140 6.913820e+00
R_6140_6240 6140 6240 7.617519e+00
R_6240_6340 6240 6340 2.046653e-01
R_6340_6440 6340 6440 2.708365e+00
R_6440_6540 6440 6540 5.789294e-01
R_6540_6640 6540 6640 8.749922e+00
R_6640_6740 6640 6740 8.702402e+00
R_6740_6840 6740 6840 8.503378e+00
R_6840_6940 6840 6940 8.253604e-01
R_6940_7040 6940 7040 1.690599e+00
R_7040_7140 7040 7140 2.184916e+00
R_7140_7240 7140 7240 7.454637e+00
R_7240_7340 7240 7340 6.892653e+00
R_7340_7440 7340 7440 2.427223e+00
R_7440_7540 7440 7540 2.326908e+00
R_7540_7640 7540 7640 1.299082e+00
R_7640_7740 7640 7740 6.074025e-01
R_7740_7840 7740 7840 9.375907e-01
R_7840_7940 7840 7940 2.977500e+00
R_7940_8040 7940 8040 1.893492e+00
R_8040_8140 8040 8140 4.565004e+00
R_8140_8240 8140 8240 6.158319e+00
R_8240_8340 8240 8340 7.697212e-01
R_8340_8440 8340 8440 5.724087e+00
R_8440_8540 8440 8540 6.822810e+00
R_8540_8640 8540 8640 1.476146e+00
R_8640_8740 8640 8740 6.721368e+00
R_8740_8840 8740 8840 9.748341e+00
R_8840_8940 8840 8940 6.388047e+00
R_8940_9040 8940 9040 9.208656e-02
R_9040_9140 9040 9140 6.469551e+00
R_9140_9240 9140 9240 3.566857e-01
R_9240_9340 9240 9340 8.577156e+00
R_9340_9440 9340 9440 8.218138e+00
R_9440_9540 9440 9540 8.881980e+00
R_9540_9640 9540 9640 1.492235e+00
R_9640_9740 9640 9740 5.103349e+00
R_9740_9840 9740 9840 2.177631e+00
R_9840_9940 9840 9940 3.764900e+00
R_41_141 41 141 6.385373e-01
R_141_241 141 241 6.252203e+00
R_241_341 241 341 3.996606e+00
R_341_441 341 441 3.374933e+00
R_441_541 441 541 5.034098e+00
R_541_641 541 641 2.224740e+00
R_641_741 641 741 2.300785e+00
R_741_841 741 841 3.204279e+00
R_841_941 841 941 7.657355e+00
R_941_1041 941 1041 8.163015e+00
R_1041_1141 1041 1141 2.366092e-01
R_1141_1241 1141 1241 8.591316e-02
R_1241_1341 1241 1341 7.896331e+00
R_1341_1441 1341 1441 5.222177e-01
R_1441_1541 1441 1541 4.349406e+00
R_1541_1641 1541 1641 7.450708e+00
R_1641_1741 1641 1741 1.415678e+00
R_1741_1841 1741 1841 1.060307e+00
R_1841_1941 1841 1941 5.893905e+00
R_1941_2041 1941 2041 7.104957e+00
R_2041_2141 2041 2141 5.183916e-01
R_2141_2241 2141 2241 2.083764e+00
R_2241_2341 2241 2341 8.665182e+00
R_2341_2441 2341 2441 9.549373e+00
R_2441_2541 2441 2541 2.696576e+00
R_2541_2641 2541 2641 9.707728e+00
R_2641_2741 2641 2741 8.165717e+00
R_2741_2841 2741 2841 7.347821e+00
R_2841_2941 2841 2941 2.481332e+00
R_2941_3041 2941 3041 7.311522e+00
R_3041_3141 3041 3141 7.666444e+00
R_3141_3241 3141 3241 1.733189e+00
R_3241_3341 3241 3341 9.126380e+00
R_3341_3441 3341 3441 1.516795e+00
R_3441_3541 3441 3541 5.611710e+00
R_3541_3641 3541 3641 1.687485e+00
R_3641_3741 3641 3741 9.387646e+00
R_3741_3841 3741 3841 9.230990e+00
R_3841_3941 3841 3941 1.386295e+00
R_3941_4041 3941 4041 5.010306e+00
R_4041_4141 4041 4141 9.660922e+00
R_4141_4241 4141 4241 7.119182e+00
R_4241_4341 4241 4341 2.482699e+00
R_4341_4441 4341 4441 8.880848e+00
R_4441_4541 4441 4541 3.586422e+00
R_4541_4641 4541 4641 6.436056e+00
R_4641_4741 4641 4741 3.124950e+00
R_4741_4841 4741 4841 6.270131e+00
R_4841_4941 4841 4941 2.447688e+00
R_4941_5041 4941 5041 7.941343e+00
R_5041_5141 5041 5141 9.619425e+00
R_5141_5241 5141 5241 1.797037e+00
R_5241_5341 5241 5341 7.776792e+00
R_5341_5441 5341 5441 9.559739e+00
R_5441_5541 5441 5541 4.088702e+00
R_5541_5641 5541 5641 2.144567e+00
R_5641_5741 5641 5741 3.559002e+00
R_5741_5841 5741 5841 7.856871e+00
R_5841_5941 5841 5941 9.362916e+00
R_5941_6041 5941 6041 6.203693e+00
R_6041_6141 6041 6141 5.332933e+00
R_6141_6241 6141 6241 2.878582e+00
R_6241_6341 6241 6341 2.992520e+00
R_6341_6441 6341 6441 9.928608e+00
R_6441_6541 6441 6541 3.459284e+00
R_6541_6641 6541 6641 9.394870e+00
R_6641_6741 6641 6741 1.923592e+00
R_6741_6841 6741 6841 6.544627e+00
R_6841_6941 6841 6941 9.371397e+00
R_6941_7041 6941 7041 6.614471e+00
R_7041_7141 7041 7141 5.565283e+00
R_7141_7241 7141 7241 3.109887e+00
R_7241_7341 7241 7341 5.275312e+00
R_7341_7441 7341 7441 2.262928e+00
R_7441_7541 7441 7541 3.045173e+00
R_7541_7641 7541 7641 5.867340e+00
R_7641_7741 7641 7741 7.175087e+00
R_7741_7841 7741 7841 4.618295e+00
R_7841_7941 7841 7941 8.252356e+00
R_7941_8041 7941 8041 5.809801e+00
R_8041_8141 8041 8141 6.395581e+00
R_8141_8241 8141 8241 5.613803e+00
R_8241_8341 8241 8341 2.256198e-01
R_8341_8441 8341 8441 8.768696e+00
R_8441_8541 8441 8541 3.083630e+00
R_8541_8641 8541 8641 3.665026e+00
R_8641_8741 8641 8741 6.083054e+00
R_8741_8841 8741 8841 6.171416e+00
R_8841_8941 8841 8941 9.418761e+00
R_8941_9041 8941 9041 5.965287e+00
R_9041_9141 9041 9141 9.008802e+00
R_9141_9241 9141 9241 3.998148e+00
R_9241_9341 9241 9341 7.247023e+00
R_9341_9441 9341 9441 5.307660e+00
R_9441_9541 9441 9541 4.030557e+00
R_9541_9641 9541 9641 7.103752e+00
R_9641_9741 9641 9741 4.195975e+00
R_9741_9841 9741 9841 8.767859e-01
R_9841_9941 9841 9941 9.100898e-01
R_42_142 42 142 4.138107e+00
R_142_242 142 242 3.160588e+00
R_242_342 242 342 4.460309e+00
R_342_442 342 442 9.045468e+00
R_442_542 442 542 9.041884e-01
R_542_642 542 642 6.640457e-01
R_642_742 642 742 1.488692e+00
R_742_842 742 842 3.881632e+00
R_842_942 842 942 8.737205e+00
R_942_1042 942 1042 6.009734e+00
R_1042_1142 1042 1142 6.660844e+00
R_1142_1242 1142 1242 1.161829e+00
R_1242_1342 1242 1342 1.741295e+00
R_1342_1442 1342 1442 7.033549e+00
R_1442_1542 1442 1542 5.547085e+00
R_1542_1642 1542 1642 6.203241e+00
R_1642_1742 1642 1742 6.423013e+00
R_1742_1842 1742 1842 2.736929e+00
R_1842_1942 1842 1942 4.229287e+00
R_1942_2042 1942 2042 5.361429e+00
R_2042_2142 2042 2142 7.380092e+00
R_2142_2242 2142 2242 7.967907e+00
R_2242_2342 2242 2342 3.714305e+00
R_2342_2442 2342 2442 5.089816e-01
R_2442_2542 2442 2542 7.373661e+00
R_2542_2642 2542 2642 6.184035e+00
R_2642_2742 2642 2742 4.284586e-01
R_2742_2842 2742 2842 2.777907e+00
R_2842_2942 2842 2942 9.174412e+00
R_2942_3042 2942 3042 9.787242e+00
R_3042_3142 3042 3142 8.708637e+00
R_3142_3242 3142 3242 6.079820e+00
R_3242_3342 3242 3342 5.956641e+00
R_3342_3442 3342 3442 1.518526e+00
R_3442_3542 3442 3542 9.045763e+00
R_3542_3642 3542 3642 8.287346e+00
R_3642_3742 3642 3742 6.328187e+00
R_3742_3842 3742 3842 4.922526e+00
R_3842_3942 3842 3942 5.247188e+00
R_3942_4042 3942 4042 8.634004e-01
R_4042_4142 4042 4142 2.739835e+00
R_4142_4242 4142 4242 3.386522e+00
R_4242_4342 4242 4342 6.204066e+00
R_4342_4442 4342 4442 2.539529e+00
R_4442_4542 4442 4542 4.436331e+00
R_4542_4642 4542 4642 8.466419e+00
R_4642_4742 4642 4742 5.392188e+00
R_4742_4842 4742 4842 5.268839e+00
R_4842_4942 4842 4942 2.375977e+00
R_4942_5042 4942 5042 7.625938e+00
R_5042_5142 5042 5142 1.743249e+00
R_5142_5242 5142 5242 9.645380e+00
R_5242_5342 5242 5342 4.828037e+00
R_5342_5442 5342 5442 9.591699e+00
R_5442_5542 5442 5542 4.540049e+00
R_5542_5642 5542 5642 8.156884e+00
R_5642_5742 5642 5742 1.033364e-01
R_5742_5842 5742 5842 8.657435e+00
R_5842_5942 5842 5942 4.493674e+00
R_5942_6042 5942 6042 6.302296e+00
R_6042_6142 6042 6142 3.701561e+00
R_6142_6242 6142 6242 5.494711e+00
R_6242_6342 6242 6342 2.309598e+00
R_6342_6442 6342 6442 6.784088e+00
R_6442_6542 6442 6542 9.641421e+00
R_6542_6642 6542 6642 8.790808e+00
R_6642_6742 6642 6742 4.020845e+00
R_6742_6842 6742 6842 6.144747e+00
R_6842_6942 6842 6942 7.851302e+00
R_6942_7042 6942 7042 4.900109e+00
R_7042_7142 7042 7142 7.362765e+00
R_7142_7242 7142 7242 2.358801e+00
R_7242_7342 7242 7342 6.183360e+00
R_7342_7442 7342 7442 8.434060e+00
R_7442_7542 7442 7542 1.133409e-01
R_7542_7642 7542 7642 1.550160e+00
R_7642_7742 7642 7742 7.711948e+00
R_7742_7842 7742 7842 9.213770e+00
R_7842_7942 7842 7942 8.823672e+00
R_7942_8042 7942 8042 2.721621e+00
R_8042_8142 8042 8142 1.496006e+00
R_8142_8242 8142 8242 8.748283e+00
R_8242_8342 8242 8342 8.661838e+00
R_8342_8442 8342 8442 8.747942e+00
R_8442_8542 8442 8542 4.497710e+00
R_8542_8642 8542 8642 8.422455e+00
R_8642_8742 8642 8742 7.544897e+00
R_8742_8842 8742 8842 1.242697e+00
R_8842_8942 8842 8942 5.678484e+00
R_8942_9042 8942 9042 5.644778e+00
R_9042_9142 9042 9142 7.691436e+00
R_9142_9242 9142 9242 7.069840e+00
R_9242_9342 9242 9342 5.290433e+00
R_9342_9442 9342 9442 6.355421e+00
R_9442_9542 9442 9542 8.201716e+00
R_9542_9642 9542 9642 6.255541e-01
R_9642_9742 9642 9742 3.369450e+00
R_9742_9842 9742 9842 9.278131e+00
R_9842_9942 9842 9942 1.627225e+00
R_43_143 43 143 5.370597e+00
R_143_243 143 243 2.543389e+00
R_243_343 243 343 8.723840e+00
R_343_443 343 443 3.340555e+00
R_443_543 443 543 5.379007e+00
R_543_643 543 643 1.470424e+00
R_643_743 643 743 9.704784e+00
R_743_843 743 843 9.893769e+00
R_843_943 843 943 9.515106e+00
R_943_1043 943 1043 5.790402e+00
R_1043_1143 1043 1143 3.506302e+00
R_1143_1243 1143 1243 5.606391e+00
R_1243_1343 1243 1343 9.583448e+00
R_1343_1443 1343 1443 3.528418e+00
R_1443_1543 1443 1543 5.792710e+00
R_1543_1643 1543 1643 3.816371e+00
R_1643_1743 1643 1743 1.018015e+00
R_1743_1843 1743 1843 6.303808e+00
R_1843_1943 1843 1943 1.326669e+00
R_1943_2043 1943 2043 8.409189e-01
R_2043_2143 2043 2143 7.590986e-01
R_2143_2243 2143 2243 7.074472e-01
R_2243_2343 2243 2343 5.355948e+00
R_2343_2443 2343 2443 4.032515e+00
R_2443_2543 2443 2543 8.517504e-01
R_2543_2643 2543 2643 5.259240e+00
R_2643_2743 2643 2743 3.812626e+00
R_2743_2843 2743 2843 7.639511e+00
R_2843_2943 2843 2943 7.768630e+00
R_2943_3043 2943 3043 7.546488e-01
R_3043_3143 3043 3143 2.906929e+00
R_3143_3243 3143 3243 7.463730e+00
R_3243_3343 3243 3343 8.502529e+00
R_3343_3443 3343 3443 9.298224e+00
R_3443_3543 3443 3543 7.442170e+00
R_3543_3643 3543 3643 5.905002e+00
R_3643_3743 3643 3743 7.120946e+00
R_3743_3843 3743 3843 1.998917e+00
R_3843_3943 3843 3943 6.919198e+00
R_3943_4043 3943 4043 9.782420e+00
R_4043_4143 4043 4143 6.268412e+00
R_4143_4243 4143 4243 5.800914e+00
R_4243_4343 4243 4343 1.923738e+00
R_4343_4443 4343 4443 7.208807e+00
R_4443_4543 4443 4543 1.759990e+00
R_4543_4643 4543 4643 4.134940e+00
R_4643_4743 4643 4743 5.671878e+00
R_4743_4843 4743 4843 4.392516e+00
R_4843_4943 4843 4943 4.447075e+00
R_4943_5043 4943 5043 4.503091e+00
R_5043_5143 5043 5143 6.132395e+00
R_5143_5243 5143 5243 4.865973e+00
R_5243_5343 5243 5343 4.733966e+00
R_5343_5443 5343 5443 2.457036e+00
R_5443_5543 5443 5543 2.735704e+00
R_5543_5643 5543 5643 5.183532e+00
R_5643_5743 5643 5743 2.047288e+00
R_5743_5843 5743 5843 5.821411e+00
R_5843_5943 5843 5943 9.212142e-01
R_5943_6043 5943 6043 3.024275e-01
R_6043_6143 6043 6143 9.486239e+00
R_6143_6243 6143 6243 8.849372e+00
R_6243_6343 6243 6343 3.821165e+00
R_6343_6443 6343 6443 9.585201e+00
R_6443_6543 6443 6543 2.751251e+00
R_6543_6643 6543 6643 9.285822e+00
R_6643_6743 6643 6743 1.038526e+00
R_6743_6843 6743 6843 6.362903e+00
R_6843_6943 6843 6943 8.359300e+00
R_6943_7043 6943 7043 6.693174e+00
R_7043_7143 7043 7143 9.163868e-01
R_7143_7243 7143 7243 9.684728e+00
R_7243_7343 7243 7343 3.924838e+00
R_7343_7443 7343 7443 3.168906e+00
R_7443_7543 7443 7543 8.036232e+00
R_7543_7643 7543 7643 4.737159e+00
R_7643_7743 7643 7743 6.652187e+00
R_7743_7843 7743 7843 1.710534e+00
R_7843_7943 7843 7943 1.503197e+00
R_7943_8043 7943 8043 3.219106e+00
R_8043_8143 8043 8143 7.496120e-02
R_8143_8243 8143 8243 9.299368e+00
R_8243_8343 8243 8343 4.458587e+00
R_8343_8443 8343 8443 9.975615e+00
R_8443_8543 8443 8543 7.899269e+00
R_8543_8643 8543 8643 1.026568e-01
R_8643_8743 8643 8743 7.952526e+00
R_8743_8843 8743 8843 5.466257e-01
R_8843_8943 8843 8943 5.980734e+00
R_8943_9043 8943 9043 3.579077e+00
R_9043_9143 9043 9143 9.134545e+00
R_9143_9243 9143 9243 1.366792e+00
R_9243_9343 9243 9343 7.468540e+00
R_9343_9443 9343 9443 4.988315e+00
R_9443_9543 9443 9543 5.946197e+00
R_9543_9643 9543 9643 1.907071e+00
R_9643_9743 9643 9743 1.529323e+00
R_9743_9843 9743 9843 1.071636e+00
R_9843_9943 9843 9943 7.011550e+00
R_44_144 44 144 4.808718e+00
R_144_244 144 244 8.972098e-01
R_244_344 244 344 5.704737e+00
R_344_444 344 444 8.093831e+00
R_444_544 444 544 6.241966e+00
R_544_644 544 644 9.432990e+00
R_644_744 644 744 3.640457e+00
R_744_844 744 844 6.240094e+00
R_844_944 844 944 7.658198e+00
R_944_1044 944 1044 6.274264e+00
R_1044_1144 1044 1144 2.354106e+00
R_1144_1244 1144 1244 1.087706e+00
R_1244_1344 1244 1344 9.057918e-01
R_1344_1444 1344 1444 4.962190e+00
R_1444_1544 1444 1544 5.397134e+00
R_1544_1644 1544 1644 5.038105e+00
R_1644_1744 1644 1744 2.930114e+00
R_1744_1844 1744 1844 6.343370e+00
R_1844_1944 1844 1944 7.724804e+00
R_1944_2044 1944 2044 6.220537e+00
R_2044_2144 2044 2144 7.719010e+00
R_2144_2244 2144 2244 9.880194e+00
R_2244_2344 2244 2344 8.846405e+00
R_2344_2444 2344 2444 6.569877e+00
R_2444_2544 2444 2544 5.277997e+00
R_2544_2644 2544 2644 6.471227e+00
R_2644_2744 2644 2744 3.020852e+00
R_2744_2844 2744 2844 4.191618e+00
R_2844_2944 2844 2944 3.294838e+00
R_2944_3044 2944 3044 6.091892e+00
R_3044_3144 3044 3144 3.744985e+00
R_3144_3244 3144 3244 5.943182e+00
R_3244_3344 3244 3344 8.768259e+00
R_3344_3444 3344 3444 9.866009e+00
R_3444_3544 3444 3544 9.048089e+00
R_3544_3644 3544 3644 5.679799e+00
R_3644_3744 3644 3744 1.095057e+00
R_3744_3844 3744 3844 4.503085e+00
R_3844_3944 3844 3944 6.833941e+00
R_3944_4044 3944 4044 7.814141e+00
R_4044_4144 4044 4144 8.776773e+00
R_4144_4244 4144 4244 4.231018e+00
R_4244_4344 4244 4344 4.742150e+00
R_4344_4444 4344 4444 2.788776e+00
R_4444_4544 4444 4544 8.645269e+00
R_4544_4644 4544 4644 6.235837e+00
R_4644_4744 4644 4744 8.484071e+00
R_4744_4844 4744 4844 8.295119e+00
R_4844_4944 4844 4944 1.107691e+00
R_4944_5044 4944 5044 4.892993e+00
R_5044_5144 5044 5144 3.187601e+00
R_5144_5244 5144 5244 6.437218e+00
R_5244_5344 5244 5344 2.632199e+00
R_5344_5444 5344 5444 5.680595e+00
R_5444_5544 5444 5544 1.791809e+00
R_5544_5644 5544 5644 6.099868e+00
R_5644_5744 5644 5744 9.551122e-01
R_5744_5844 5744 5844 8.051999e+00
R_5844_5944 5844 5944 3.364053e+00
R_5944_6044 5944 6044 9.114735e+00
R_6044_6144 6044 6144 9.062712e+00
R_6144_6244 6144 6244 6.178251e+00
R_6244_6344 6244 6344 5.891388e+00
R_6344_6444 6344 6444 7.111754e+00
R_6444_6544 6444 6544 8.198860e+00
R_6544_6644 6544 6644 4.737269e+00
R_6644_6744 6644 6744 1.166016e+00
R_6744_6844 6744 6844 2.451212e+00
R_6844_6944 6844 6944 1.076789e+00
R_6944_7044 6944 7044 1.580021e+00
R_7044_7144 7044 7144 8.655208e+00
R_7144_7244 7144 7244 9.943681e+00
R_7244_7344 7244 7344 2.682850e+00
R_7344_7444 7344 7444 4.917979e-01
R_7444_7544 7444 7544 2.736337e+00
R_7544_7644 7544 7644 1.604525e+00
R_7644_7744 7644 7744 9.401062e-01
R_7744_7844 7744 7844 9.019787e+00
R_7844_7944 7844 7944 7.541434e+00
R_7944_8044 7944 8044 7.406189e+00
R_8044_8144 8044 8144 7.341429e+00
R_8144_8244 8144 8244 7.742032e-01
R_8244_8344 8244 8344 3.407256e+00
R_8344_8444 8344 8444 9.650637e-01
R_8444_8544 8444 8544 3.717549e+00
R_8544_8644 8544 8644 5.808248e+00
R_8644_8744 8644 8744 7.320865e+00
R_8744_8844 8744 8844 8.611290e+00
R_8844_8944 8844 8944 4.986581e+00
R_8944_9044 8944 9044 7.930098e+00
R_9044_9144 9044 9144 3.544212e+00
R_9144_9244 9144 9244 3.821022e+00
R_9244_9344 9244 9344 4.988815e-01
R_9344_9444 9344 9444 1.156605e+00
R_9444_9544 9444 9544 2.733747e+00
R_9544_9644 9544 9644 3.187238e+00
R_9644_9744 9644 9744 7.174106e+00
R_9744_9844 9744 9844 4.956572e+00
R_9844_9944 9844 9944 2.028957e+00
R_45_145 45 145 8.096677e+00
R_145_245 145 245 4.054269e+00
R_245_345 245 345 9.760727e+00
R_345_445 345 445 4.361383e+00
R_445_545 445 545 9.306988e+00
R_545_645 545 645 6.562073e+00
R_645_745 645 745 9.653732e+00
R_745_845 745 845 4.530282e+00
R_845_945 845 945 4.199533e+00
R_945_1045 945 1045 3.177362e+00
R_1045_1145 1045 1145 3.188079e+00
R_1145_1245 1145 1245 4.567322e-01
R_1245_1345 1245 1345 7.118408e+00
R_1345_1445 1345 1445 5.150105e-01
R_1445_1545 1445 1545 6.482204e+00
R_1545_1645 1545 1645 4.780936e+00
R_1645_1745 1645 1745 1.646645e+00
R_1745_1845 1745 1845 9.501038e+00
R_1845_1945 1845 1945 4.479849e+00
R_1945_2045 1945 2045 9.646249e+00
R_2045_2145 2045 2145 8.003481e+00
R_2145_2245 2145 2245 9.169740e+00
R_2245_2345 2245 2345 7.447661e-01
R_2345_2445 2345 2445 9.249464e+00
R_2445_2545 2445 2545 7.879553e+00
R_2545_2645 2545 2645 6.685842e+00
R_2645_2745 2645 2745 7.361028e+00
R_2745_2845 2745 2845 7.864752e+00
R_2845_2945 2845 2945 3.371230e+00
R_2945_3045 2945 3045 1.531155e-01
R_3045_3145 3045 3145 4.125401e+00
R_3145_3245 3145 3245 4.520175e+00
R_3245_3345 3245 3345 2.955720e+00
R_3345_3445 3345 3445 5.127136e+00
R_3445_3545 3445 3545 4.553225e+00
R_3545_3645 3545 3645 2.600170e-01
R_3645_3745 3645 3745 5.527409e+00
R_3745_3845 3745 3845 2.541937e+00
R_3845_3945 3845 3945 5.683513e+00
R_3945_4045 3945 4045 5.373101e+00
R_4045_4145 4045 4145 2.619465e+00
R_4145_4245 4145 4245 9.568149e+00
R_4245_4345 4245 4345 4.950740e+00
R_4345_4445 4345 4445 8.228574e+00
R_4445_4545 4445 4545 8.523402e+00
R_4545_4645 4545 4645 8.361917e+00
R_4645_4745 4645 4745 1.566131e+00
R_4745_4845 4745 4845 3.137652e+00
R_4845_4945 4845 4945 3.924215e-01
R_4945_5045 4945 5045 5.863271e+00
R_5045_5145 5045 5145 5.651355e+00
R_5145_5245 5145 5245 8.710474e+00
R_5245_5345 5245 5345 9.409585e+00
R_5345_5445 5345 5445 5.800034e+00
R_5445_5545 5445 5545 2.818343e+00
R_5545_5645 5545 5645 3.503824e+00
R_5645_5745 5645 5745 1.416894e+00
R_5745_5845 5745 5845 6.136658e-01
R_5845_5945 5845 5945 1.031300e+00
R_5945_6045 5945 6045 7.840617e-01
R_6045_6145 6045 6145 4.275183e+00
R_6145_6245 6145 6245 1.869892e-01
R_6245_6345 6245 6345 3.708575e-01
R_6345_6445 6345 6445 9.748331e+00
R_6445_6545 6445 6545 7.290445e+00
R_6545_6645 6545 6645 6.621390e-01
R_6645_6745 6645 6745 6.782108e-01
R_6745_6845 6745 6845 3.101363e+00
R_6845_6945 6845 6945 9.860892e+00
R_6945_7045 6945 7045 4.426511e+00
R_7045_7145 7045 7145 5.929522e+00
R_7145_7245 7145 7245 5.364903e+00
R_7245_7345 7245 7345 4.071928e+00
R_7345_7445 7345 7445 9.084578e-01
R_7445_7545 7445 7545 3.546410e+00
R_7545_7645 7545 7645 2.373012e+00
R_7645_7745 7645 7745 3.346511e+00
R_7745_7845 7745 7845 6.252004e+00
R_7845_7945 7845 7945 9.133451e-01
R_7945_8045 7945 8045 4.230190e+00
R_8045_8145 8045 8145 2.400401e+00
R_8145_8245 8145 8245 2.059654e+00
R_8245_8345 8245 8345 9.872224e+00
R_8345_8445 8345 8445 4.682685e+00
R_8445_8545 8445 8545 9.159705e+00
R_8545_8645 8545 8645 9.526363e+00
R_8645_8745 8645 8745 7.804434e+00
R_8745_8845 8745 8845 7.714427e+00
R_8845_8945 8845 8945 3.777646e+00
R_8945_9045 8945 9045 4.831057e+00
R_9045_9145 9045 9145 4.527916e+00
R_9145_9245 9145 9245 3.852734e+00
R_9245_9345 9245 9345 3.630067e-01
R_9345_9445 9345 9445 1.074316e+00
R_9445_9545 9445 9545 6.489742e+00
R_9545_9645 9545 9645 8.163450e+00
R_9645_9745 9645 9745 4.862546e+00
R_9745_9845 9745 9845 9.564574e+00
R_9845_9945 9845 9945 9.278747e+00
R_46_146 46 146 2.248588e+00
R_146_246 146 246 6.539869e+00
R_246_346 246 346 3.973960e+00
R_346_446 346 446 4.290587e+00
R_446_546 446 546 4.087494e+00
R_546_646 546 646 8.220235e+00
R_646_746 646 746 7.194225e-01
R_746_846 746 846 3.767693e-01
R_846_946 846 946 9.001222e+00
R_946_1046 946 1046 6.157865e+00
R_1046_1146 1046 1146 6.390255e+00
R_1146_1246 1146 1246 9.714522e+00
R_1246_1346 1246 1346 7.471273e+00
R_1346_1446 1346 1446 8.352150e-01
R_1446_1546 1446 1546 2.031272e+00
R_1546_1646 1546 1646 5.952233e-01
R_1646_1746 1646 1746 4.178662e+00
R_1746_1846 1746 1846 6.321531e+00
R_1846_1946 1846 1946 4.977793e+00
R_1946_2046 1946 2046 1.232714e+00
R_2046_2146 2046 2146 3.017514e+00
R_2146_2246 2146 2246 4.115700e+00
R_2246_2346 2246 2346 3.803582e+00
R_2346_2446 2346 2446 3.579597e+00
R_2446_2546 2446 2546 5.762615e+00
R_2546_2646 2546 2646 2.735566e-01
R_2646_2746 2646 2746 3.967934e+00
R_2746_2846 2746 2846 9.120055e-01
R_2846_2946 2846 2946 6.059976e+00
R_2946_3046 2946 3046 7.538305e+00
R_3046_3146 3046 3146 9.300526e+00
R_3146_3246 3146 3246 5.608465e+00
R_3246_3346 3246 3346 5.043698e+00
R_3346_3446 3346 3446 5.559887e+00
R_3446_3546 3446 3546 9.661132e+00
R_3546_3646 3546 3646 4.161539e+00
R_3646_3746 3646 3746 3.204134e+00
R_3746_3846 3746 3846 4.055955e+00
R_3846_3946 3846 3946 9.019140e+00
R_3946_4046 3946 4046 8.762737e-02
R_4046_4146 4046 4146 7.487869e-01
R_4146_4246 4146 4246 5.435441e+00
R_4246_4346 4246 4346 7.099016e+00
R_4346_4446 4346 4446 7.284536e+00
R_4446_4546 4446 4546 6.208001e+00
R_4546_4646 4546 4646 1.609221e+00
R_4646_4746 4646 4746 2.965029e+00
R_4746_4846 4746 4846 9.668380e+00
R_4846_4946 4846 4946 7.749027e+00
R_4946_5046 4946 5046 1.359708e+00
R_5046_5146 5046 5146 8.144794e+00
R_5146_5246 5146 5246 2.441444e+00
R_5246_5346 5246 5346 9.332595e+00
R_5346_5446 5346 5446 5.656810e+00
R_5446_5546 5446 5546 5.304252e+00
R_5546_5646 5546 5646 4.206353e+00
R_5646_5746 5646 5746 6.631228e+00
R_5746_5846 5746 5846 9.936798e+00
R_5846_5946 5846 5946 2.365097e+00
R_5946_6046 5946 6046 1.359790e+00
R_6046_6146 6046 6146 3.750856e+00
R_6146_6246 6146 6246 8.878697e+00
R_6246_6346 6246 6346 7.122901e+00
R_6346_6446 6346 6446 3.276153e+00
R_6446_6546 6446 6546 5.626878e+00
R_6546_6646 6546 6646 7.544999e+00
R_6646_6746 6646 6746 7.245388e+00
R_6746_6846 6746 6846 2.046645e+00
R_6846_6946 6846 6946 3.397694e+00
R_6946_7046 6946 7046 3.627655e+00
R_7046_7146 7046 7146 6.772587e+00
R_7146_7246 7146 7246 9.001445e+00
R_7246_7346 7246 7346 6.809559e+00
R_7346_7446 7346 7446 8.714895e+00
R_7446_7546 7446 7546 8.895588e+00
R_7546_7646 7546 7646 8.950289e+00
R_7646_7746 7646 7746 6.078421e+00
R_7746_7846 7746 7846 2.175475e+00
R_7846_7946 7846 7946 1.425173e+00
R_7946_8046 7946 8046 9.663738e+00
R_8046_8146 8046 8146 3.216409e+00
R_8146_8246 8146 8246 9.183342e+00
R_8246_8346 8246 8346 8.964978e+00
R_8346_8446 8346 8446 2.060102e+00
R_8446_8546 8446 8546 5.337598e+00
R_8546_8646 8546 8646 9.544550e-01
R_8646_8746 8646 8746 4.593908e+00
R_8746_8846 8746 8846 9.111212e+00
R_8846_8946 8846 8946 3.527137e+00
R_8946_9046 8946 9046 7.874478e-02
R_9046_9146 9046 9146 7.266087e+00
R_9146_9246 9146 9246 2.936743e+00
R_9246_9346 9246 9346 8.530195e+00
R_9346_9446 9346 9446 9.304249e+00
R_9446_9546 9446 9546 7.902413e+00
R_9546_9646 9546 9646 8.946060e+00
R_9646_9746 9646 9746 6.458400e+00
R_9746_9846 9746 9846 3.635498e+00
R_9846_9946 9846 9946 9.378929e-03
R_47_147 47 147 1.104228e+00
R_147_247 147 247 7.173129e+00
R_247_347 247 347 9.272780e+00
R_347_447 347 447 2.354933e+00
R_447_547 447 547 2.241364e-02
R_547_647 547 647 2.353687e+00
R_647_747 647 747 3.661978e+00
R_747_847 747 847 5.585286e+00
R_847_947 847 947 9.993210e+00
R_947_1047 947 1047 8.726142e+00
R_1047_1147 1047 1147 3.299823e+00
R_1147_1247 1147 1247 5.468902e-01
R_1247_1347 1247 1347 7.092966e+00
R_1347_1447 1347 1447 7.302823e+00
R_1447_1547 1447 1547 5.619865e+00
R_1547_1647 1547 1647 4.178009e+00
R_1647_1747 1647 1747 2.624050e+00
R_1747_1847 1747 1847 6.913570e+00
R_1847_1947 1847 1947 4.856247e+00
R_1947_2047 1947 2047 9.361788e+00
R_2047_2147 2047 2147 6.716092e+00
R_2147_2247 2147 2247 7.404474e+00
R_2247_2347 2247 2347 5.038547e+00
R_2347_2447 2347 2447 6.494995e+00
R_2447_2547 2447 2547 7.041348e+00
R_2547_2647 2547 2647 3.465169e+00
R_2647_2747 2647 2747 7.380556e+00
R_2747_2847 2747 2847 4.975165e+00
R_2847_2947 2847 2947 1.244791e+00
R_2947_3047 2947 3047 7.838714e+00
R_3047_3147 3047 3147 1.763320e+00
R_3147_3247 3147 3247 5.149797e+00
R_3247_3347 3247 3347 3.158361e+00
R_3347_3447 3347 3447 5.183530e+00
R_3447_3547 3447 3547 4.472917e-01
R_3547_3647 3547 3647 9.486960e+00
R_3647_3747 3647 3747 7.354083e-01
R_3747_3847 3747 3847 5.401566e+00
R_3847_3947 3847 3947 5.263154e+00
R_3947_4047 3947 4047 3.847363e+00
R_4047_4147 4047 4147 7.288439e+00
R_4147_4247 4147 4247 5.425147e+00
R_4247_4347 4247 4347 3.437150e+00
R_4347_4447 4347 4447 2.450748e+00
R_4447_4547 4447 4547 4.415455e+00
R_4547_4647 4547 4647 7.927774e+00
R_4647_4747 4647 4747 5.329042e+00
R_4747_4847 4747 4847 9.715588e-01
R_4847_4947 4847 4947 8.141632e+00
R_4947_5047 4947 5047 1.042289e+00
R_5047_5147 5047 5147 7.802506e+00
R_5147_5247 5147 5247 5.962982e-01
R_5247_5347 5247 5347 7.878901e+00
R_5347_5447 5347 5447 6.703099e+00
R_5447_5547 5447 5547 6.320624e-01
R_5547_5647 5547 5647 6.982435e+00
R_5647_5747 5647 5747 9.568333e+00
R_5747_5847 5747 5847 8.401979e+00
R_5847_5947 5847 5947 3.275307e+00
R_5947_6047 5947 6047 2.594315e+00
R_6047_6147 6047 6147 7.535268e+00
R_6147_6247 6147 6247 8.947457e+00
R_6247_6347 6247 6347 7.115598e-01
R_6347_6447 6347 6447 6.303488e+00
R_6447_6547 6447 6547 4.579522e+00
R_6547_6647 6547 6647 5.777676e+00
R_6647_6747 6647 6747 9.434049e+00
R_6747_6847 6747 6847 4.085520e+00
R_6847_6947 6847 6947 8.605615e+00
R_6947_7047 6947 7047 1.680085e+00
R_7047_7147 7047 7147 5.636070e+00
R_7147_7247 7147 7247 6.899414e+00
R_7247_7347 7247 7347 7.811339e+00
R_7347_7447 7347 7447 6.854105e+00
R_7447_7547 7447 7547 1.549503e+00
R_7547_7647 7547 7647 9.305207e+00
R_7647_7747 7647 7747 5.560069e+00
R_7747_7847 7747 7847 5.080029e+00
R_7847_7947 7847 7947 7.664958e+00
R_7947_8047 7947 8047 7.634368e+00
R_8047_8147 8047 8147 4.071127e-01
R_8147_8247 8147 8247 2.879825e+00
R_8247_8347 8247 8347 3.651151e-01
R_8347_8447 8347 8447 6.625913e+00
R_8447_8547 8447 8547 6.927868e+00
R_8547_8647 8547 8647 5.354865e+00
R_8647_8747 8647 8747 9.054018e+00
R_8747_8847 8747 8847 3.670442e+00
R_8847_8947 8847 8947 8.298945e+00
R_8947_9047 8947 9047 9.290782e+00
R_9047_9147 9047 9147 9.294673e+00
R_9147_9247 9147 9247 1.544649e+00
R_9247_9347 9247 9347 7.658145e+00
R_9347_9447 9347 9447 2.674023e+00
R_9447_9547 9447 9547 3.286846e+00
R_9547_9647 9547 9647 9.614825e-01
R_9647_9747 9647 9747 8.749970e+00
R_9747_9847 9747 9847 8.788914e+00
R_9847_9947 9847 9947 3.567642e+00
R_48_148 48 148 1.585496e+00
R_148_248 148 248 6.692707e+00
R_248_348 248 348 2.429629e+00
R_348_448 348 448 9.762325e+00
R_448_548 448 548 8.377997e+00
R_548_648 548 648 1.940773e+00
R_648_748 648 748 9.756620e+00
R_748_848 748 848 4.844285e+00
R_848_948 848 948 7.356669e+00
R_948_1048 948 1048 1.612465e+00
R_1048_1148 1048 1148 4.676262e+00
R_1148_1248 1148 1248 5.406596e+00
R_1248_1348 1248 1348 4.290863e-01
R_1348_1448 1348 1448 9.209893e+00
R_1448_1548 1448 1548 5.428685e+00
R_1548_1648 1548 1648 7.492434e+00
R_1648_1748 1648 1748 3.771814e+00
R_1748_1848 1748 1848 5.952399e+00
R_1848_1948 1848 1948 3.056313e+00
R_1948_2048 1948 2048 8.798435e+00
R_2048_2148 2048 2148 9.991158e+00
R_2148_2248 2148 2248 4.662129e-01
R_2248_2348 2248 2348 6.064364e+00
R_2348_2448 2348 2448 9.864130e+00
R_2448_2548 2448 2548 1.841874e+00
R_2548_2648 2548 2648 2.292614e+00
R_2648_2748 2648 2748 3.812837e+00
R_2748_2848 2748 2848 8.530949e-01
R_2848_2948 2848 2948 9.471386e+00
R_2948_3048 2948 3048 4.654567e-01
R_3048_3148 3048 3148 3.031852e+00
R_3148_3248 3148 3248 1.777642e-01
R_3248_3348 3248 3348 2.247052e+00
R_3348_3448 3348 3448 2.310276e+00
R_3448_3548 3448 3548 2.472796e+00
R_3548_3648 3548 3648 7.547943e+00
R_3648_3748 3648 3748 6.309415e+00
R_3748_3848 3748 3848 2.623386e+00
R_3848_3948 3848 3948 8.320079e+00
R_3948_4048 3948 4048 5.970541e+00
R_4048_4148 4048 4148 3.360616e+00
R_4148_4248 4148 4248 8.724907e+00
R_4248_4348 4248 4348 9.485178e+00
R_4348_4448 4348 4448 2.406142e+00
R_4448_4548 4448 4548 3.104237e+00
R_4548_4648 4548 4648 6.802335e+00
R_4648_4748 4648 4748 9.341037e+00
R_4748_4848 4748 4848 4.695427e+00
R_4848_4948 4848 4948 6.957231e+00
R_4948_5048 4948 5048 7.263145e+00
R_5048_5148 5048 5148 1.452431e+00
R_5148_5248 5148 5248 5.896348e+00
R_5248_5348 5248 5348 7.024799e+00
R_5348_5448 5348 5448 8.620243e+00
R_5448_5548 5448 5548 4.242816e+00
R_5548_5648 5548 5648 9.973039e+00
R_5648_5748 5648 5748 1.191742e+00
R_5748_5848 5748 5848 4.765287e+00
R_5848_5948 5848 5948 6.760937e+00
R_5948_6048 5948 6048 3.298901e-01
R_6048_6148 6048 6148 4.659493e+00
R_6148_6248 6148 6248 8.870807e+00
R_6248_6348 6248 6348 3.909882e+00
R_6348_6448 6348 6448 3.184413e+00
R_6448_6548 6448 6548 3.506813e+00
R_6548_6648 6548 6648 8.688235e+00
R_6648_6748 6648 6748 3.947119e+00
R_6748_6848 6748 6848 4.034629e+00
R_6848_6948 6848 6948 6.975515e+00
R_6948_7048 6948 7048 1.571765e+00
R_7048_7148 7048 7148 6.147926e+00
R_7148_7248 7148 7248 5.228446e-01
R_7248_7348 7248 7348 9.941528e-02
R_7348_7448 7348 7448 1.054313e+00
R_7448_7548 7448 7548 2.607732e+00
R_7548_7648 7548 7648 7.532599e+00
R_7648_7748 7648 7748 5.955774e+00
R_7748_7848 7748 7848 1.852693e-01
R_7848_7948 7848 7948 4.615609e-01
R_7948_8048 7948 8048 9.879740e+00
R_8048_8148 8048 8148 5.684348e+00
R_8148_8248 8148 8248 6.742990e+00
R_8248_8348 8248 8348 3.523065e+00
R_8348_8448 8348 8448 5.959336e+00
R_8448_8548 8448 8548 3.975534e-01
R_8548_8648 8548 8648 9.078096e+00
R_8648_8748 8648 8748 5.237126e-01
R_8748_8848 8748 8848 3.784294e+00
R_8848_8948 8848 8948 2.610271e+00
R_8948_9048 8948 9048 3.054797e+00
R_9048_9148 9048 9148 7.721099e+00
R_9148_9248 9148 9248 2.170145e+00
R_9248_9348 9248 9348 8.868927e+00
R_9348_9448 9348 9448 6.241433e+00
R_9448_9548 9448 9548 9.717860e+00
R_9548_9648 9548 9648 7.714594e+00
R_9648_9748 9648 9748 3.176220e+00
R_9748_9848 9748 9848 5.958405e+00
R_9848_9948 9848 9948 9.746444e+00
R_49_149 49 149 4.218193e+00
R_149_249 149 249 3.378003e+00
R_249_349 249 349 1.625328e+00
R_349_449 349 449 8.116154e-01
R_449_549 449 549 1.380445e+00
R_549_649 549 649 3.255223e+00
R_649_749 649 749 2.779114e+00
R_749_849 749 849 1.925772e+00
R_849_949 849 949 4.943984e+00
R_949_1049 949 1049 4.204010e+00
R_1049_1149 1049 1149 1.863802e+00
R_1149_1249 1149 1249 2.564991e+00
R_1249_1349 1249 1349 5.225011e+00
R_1349_1449 1349 1449 4.888255e+00
R_1449_1549 1449 1549 8.538733e+00
R_1549_1649 1549 1649 1.965881e+00
R_1649_1749 1649 1749 4.199626e+00
R_1749_1849 1749 1849 7.991012e+00
R_1849_1949 1849 1949 4.003031e+00
R_1949_2049 1949 2049 1.819550e-03
R_2049_2149 2049 2149 1.888468e+00
R_2149_2249 2149 2249 6.421040e+00
R_2249_2349 2249 2349 1.640361e+00
R_2349_2449 2349 2449 8.862180e+00
R_2449_2549 2449 2549 7.767250e+00
R_2549_2649 2549 2649 6.755567e+00
R_2649_2749 2649 2749 2.582539e+00
R_2749_2849 2749 2849 9.712777e-02
R_2849_2949 2849 2949 2.717052e+00
R_2949_3049 2949 3049 5.402053e+00
R_3049_3149 3049 3149 3.199749e+00
R_3149_3249 3149 3249 9.533882e+00
R_3249_3349 3249 3349 8.816576e+00
R_3349_3449 3349 3449 6.016950e+00
R_3449_3549 3449 3549 9.897394e+00
R_3549_3649 3549 3649 6.040155e+00
R_3649_3749 3649 3749 8.664253e+00
R_3749_3849 3749 3849 4.899194e-01
R_3849_3949 3849 3949 4.962567e+00
R_3949_4049 3949 4049 8.216437e+00
R_4049_4149 4049 4149 3.811727e+00
R_4149_4249 4149 4249 6.495243e+00
R_4249_4349 4249 4349 9.304684e+00
R_4349_4449 4349 4449 5.941218e+00
R_4449_4549 4449 4549 9.073107e+00
R_4549_4649 4549 4649 6.067796e+00
R_4649_4749 4649 4749 5.984644e+00
R_4749_4849 4749 4849 9.016423e+00
R_4849_4949 4849 4949 2.016223e+00
R_4949_5049 4949 5049 2.040287e-01
R_5049_5149 5049 5149 8.491314e+00
R_5149_5249 5149 5249 2.477356e+00
R_5249_5349 5249 5349 4.503099e-01
R_5349_5449 5349 5449 8.489183e+00
R_5449_5549 5449 5549 1.765631e+00
R_5549_5649 5549 5649 2.738655e+00
R_5649_5749 5649 5749 2.840952e+00
R_5749_5849 5749 5849 2.682426e+00
R_5849_5949 5849 5949 9.220120e+00
R_5949_6049 5949 6049 4.682310e+00
R_6049_6149 6049 6149 7.530967e+00
R_6149_6249 6149 6249 9.761620e+00
R_6249_6349 6249 6349 5.624724e+00
R_6349_6449 6349 6449 1.262264e+00
R_6449_6549 6449 6549 8.536209e+00
R_6549_6649 6549 6649 2.598440e+00
R_6649_6749 6649 6749 7.346979e+00
R_6749_6849 6749 6849 1.014906e+00
R_6849_6949 6849 6949 9.739248e+00
R_6949_7049 6949 7049 4.948325e+00
R_7049_7149 7049 7149 6.385341e-01
R_7149_7249 7149 7249 3.175267e+00
R_7249_7349 7249 7349 8.008903e+00
R_7349_7449 7349 7449 8.658457e+00
R_7449_7549 7449 7549 5.911069e+00
R_7549_7649 7549 7649 9.142680e+00
R_7649_7749 7649 7749 1.942003e+00
R_7749_7849 7749 7849 7.758744e+00
R_7849_7949 7849 7949 4.479903e+00
R_7949_8049 7949 8049 7.719626e+00
R_8049_8149 8049 8149 1.248450e+00
R_8149_8249 8149 8249 5.916128e-01
R_8249_8349 8249 8349 1.962375e+00
R_8349_8449 8349 8449 9.827966e+00
R_8449_8549 8449 8549 4.198730e+00
R_8549_8649 8549 8649 6.164718e+00
R_8649_8749 8649 8749 4.389428e+00
R_8749_8849 8749 8849 5.581589e+00
R_8849_8949 8849 8949 4.521506e+00
R_8949_9049 8949 9049 8.235652e+00
R_9049_9149 9049 9149 8.290291e+00
R_9149_9249 9149 9249 2.869919e+00
R_9249_9349 9249 9349 1.732305e-01
R_9349_9449 9349 9449 7.083676e+00
R_9449_9549 9449 9549 1.779480e+00
R_9549_9649 9549 9649 6.687530e+00
R_9649_9749 9649 9749 6.192783e+00
R_9749_9849 9749 9849 7.822402e+00
R_9849_9949 9849 9949 5.255643e+00
R_50_150 50 150 8.050642e+00
R_150_250 150 250 3.695599e-01
R_250_350 250 350 5.733309e+00
R_350_450 350 450 2.711159e+00
R_450_550 450 550 2.633183e+00
R_550_650 550 650 5.053521e+00
R_650_750 650 750 2.078961e+00
R_750_850 750 850 7.418594e+00
R_850_950 850 950 1.373657e+00
R_950_1050 950 1050 2.330830e+00
R_1050_1150 1050 1150 3.577867e-01
R_1150_1250 1150 1250 4.840298e+00
R_1250_1350 1250 1350 6.773346e+00
R_1350_1450 1350 1450 9.007471e+00
R_1450_1550 1450 1550 7.335291e+00
R_1550_1650 1550 1650 5.651822e+00
R_1650_1750 1650 1750 2.017690e+00
R_1750_1850 1750 1850 4.266946e+00
R_1850_1950 1850 1950 6.704786e+00
R_1950_2050 1950 2050 7.823355e-01
R_2050_2150 2050 2150 8.913849e+00
R_2150_2250 2150 2250 1.706212e+00
R_2250_2350 2250 2350 2.777764e-01
R_2350_2450 2350 2450 3.588284e+00
R_2450_2550 2450 2550 1.101962e+00
R_2550_2650 2550 2650 3.595695e+00
R_2650_2750 2650 2750 2.379841e+00
R_2750_2850 2750 2850 4.225610e+00
R_2850_2950 2850 2950 6.257620e+00
R_2950_3050 2950 3050 4.545746e+00
R_3050_3150 3050 3150 3.485652e+00
R_3150_3250 3150 3250 4.857769e+00
R_3250_3350 3250 3350 4.082643e+00
R_3350_3450 3350 3450 7.490694e+00
R_3450_3550 3450 3550 1.025586e+00
R_3550_3650 3550 3650 4.491515e+00
R_3650_3750 3650 3750 3.339504e+00
R_3750_3850 3750 3850 7.539225e+00
R_3850_3950 3850 3950 5.927786e+00
R_3950_4050 3950 4050 1.767179e+00
R_4050_4150 4050 4150 7.291970e+00
R_4150_4250 4150 4250 7.909582e+00
R_4250_4350 4250 4350 3.525127e+00
R_4350_4450 4350 4450 6.819617e+00
R_4450_4550 4450 4550 4.314135e-02
R_4550_4650 4550 4650 7.309446e+00
R_4650_4750 4650 4750 8.500232e+00
R_4750_4850 4750 4850 8.693867e+00
R_4850_4950 4850 4950 6.428460e+00
R_4950_5050 4950 5050 2.296361e+00
R_5050_5150 5050 5150 5.330508e+00
R_5150_5250 5150 5250 5.057917e+00
R_5250_5350 5250 5350 6.566096e-01
R_5350_5450 5350 5450 9.505338e+00
R_5450_5550 5450 5550 9.677327e+00
R_5550_5650 5550 5650 9.002248e+00
R_5650_5750 5650 5750 4.654771e+00
R_5750_5850 5750 5850 1.488429e+00
R_5850_5950 5850 5950 7.020131e+00
R_5950_6050 5950 6050 4.794544e+00
R_6050_6150 6050 6150 9.589889e+00
R_6150_6250 6150 6250 7.439385e+00
R_6250_6350 6250 6350 2.785648e-01
R_6350_6450 6350 6450 5.142164e+00
R_6450_6550 6450 6550 4.145975e+00
R_6550_6650 6550 6650 1.142424e+00
R_6650_6750 6650 6750 4.392716e+00
R_6750_6850 6750 6850 4.251015e+00
R_6850_6950 6850 6950 9.779005e+00
R_6950_7050 6950 7050 8.511204e+00
R_7050_7150 7050 7150 7.635889e+00
R_7150_7250 7150 7250 1.096381e+00
R_7250_7350 7250 7350 3.475728e+00
R_7350_7450 7350 7450 9.974554e+00
R_7450_7550 7450 7550 4.568633e+00
R_7550_7650 7550 7650 7.611729e+00
R_7650_7750 7650 7750 7.948486e+00
R_7750_7850 7750 7850 7.388792e+00
R_7850_7950 7850 7950 6.255040e+00
R_7950_8050 7950 8050 3.021872e+00
R_8050_8150 8050 8150 5.487510e+00
R_8150_8250 8150 8250 8.742431e+00
R_8250_8350 8250 8350 3.826470e-01
R_8350_8450 8350 8450 2.852645e+00
R_8450_8550 8450 8550 6.650927e+00
R_8550_8650 8550 8650 7.113358e+00
R_8650_8750 8650 8750 6.529400e+00
R_8750_8850 8750 8850 1.427723e+00
R_8850_8950 8850 8950 8.148615e+00
R_8950_9050 8950 9050 6.744779e+00
R_9050_9150 9050 9150 5.401281e+00
R_9150_9250 9150 9250 7.399872e+00
R_9250_9350 9250 9350 9.995735e+00
R_9350_9450 9350 9450 6.008086e+00
R_9450_9550 9450 9550 5.527142e+00
R_9550_9650 9550 9650 4.989581e+00
R_9650_9750 9650 9750 6.813605e+00
R_9750_9850 9750 9850 9.096990e+00
R_9850_9950 9850 9950 2.310988e+00
R_51_151 51 151 4.165473e+00
R_151_251 151 251 7.531649e-01
R_251_351 251 351 7.870126e+00
R_351_451 351 451 7.244027e+00
R_451_551 451 551 6.554453e+00
R_551_651 551 651 4.425366e+00
R_651_751 651 751 8.640945e+00
R_751_851 751 851 1.771497e+00
R_851_951 851 951 4.587330e+00
R_951_1051 951 1051 4.900075e+00
R_1051_1151 1051 1151 7.548221e+00
R_1151_1251 1151 1251 1.413360e+00
R_1251_1351 1251 1351 6.068770e+00
R_1351_1451 1351 1451 2.737394e+00
R_1451_1551 1451 1551 8.822835e+00
R_1551_1651 1551 1651 6.439146e-01
R_1651_1751 1651 1751 2.149386e+00
R_1751_1851 1751 1851 2.505414e+00
R_1851_1951 1851 1951 6.189963e+00
R_1951_2051 1951 2051 6.361183e-01
R_2051_2151 2051 2151 1.503946e+00
R_2151_2251 2151 2251 9.018208e+00
R_2251_2351 2251 2351 2.120211e+00
R_2351_2451 2351 2451 5.886991e+00
R_2451_2551 2451 2551 4.452617e+00
R_2551_2651 2551 2651 6.537128e+00
R_2651_2751 2651 2751 9.539314e+00
R_2751_2851 2751 2851 9.345438e+00
R_2851_2951 2851 2951 3.588718e+00
R_2951_3051 2951 3051 8.039994e+00
R_3051_3151 3051 3151 6.707487e+00
R_3151_3251 3151 3251 5.198143e-01
R_3251_3351 3251 3351 1.709080e+00
R_3351_3451 3351 3451 6.295528e+00
R_3451_3551 3451 3551 5.127001e+00
R_3551_3651 3551 3651 6.272925e+00
R_3651_3751 3651 3751 2.088258e+00
R_3751_3851 3751 3851 6.979181e-01
R_3851_3951 3851 3951 2.531033e+00
R_3951_4051 3951 4051 6.915916e+00
R_4051_4151 4051 4151 3.685333e+00
R_4151_4251 4151 4251 7.203253e+00
R_4251_4351 4251 4351 5.615926e+00
R_4351_4451 4351 4451 3.944116e+00
R_4451_4551 4451 4551 7.997808e+00
R_4551_4651 4551 4651 9.390264e+00
R_4651_4751 4651 4751 4.544073e+00
R_4751_4851 4751 4851 2.114792e+00
R_4851_4951 4851 4951 1.551132e+00
R_4951_5051 4951 5051 9.152697e+00
R_5051_5151 5051 5151 6.094417e+00
R_5151_5251 5151 5251 3.423025e+00
R_5251_5351 5251 5351 1.446650e+00
R_5351_5451 5351 5451 5.029240e+00
R_5451_5551 5451 5551 4.356567e+00
R_5551_5651 5551 5651 9.990239e-01
R_5651_5751 5651 5751 1.277201e+00
R_5751_5851 5751 5851 9.004047e+00
R_5851_5951 5851 5951 9.370138e+00
R_5951_6051 5951 6051 1.213320e-01
R_6051_6151 6051 6151 1.760751e+00
R_6151_6251 6151 6251 1.563581e+00
R_6251_6351 6251 6351 2.365202e+00
R_6351_6451 6351 6451 7.431735e+00
R_6451_6551 6451 6551 4.996748e-01
R_6551_6651 6551 6651 7.123186e+00
R_6651_6751 6651 6751 6.458002e+00
R_6751_6851 6751 6851 1.261432e-01
R_6851_6951 6851 6951 5.790470e+00
R_6951_7051 6951 7051 2.999267e+00
R_7051_7151 7051 7151 9.341792e+00
R_7151_7251 7151 7251 7.102086e+00
R_7251_7351 7251 7351 4.720094e+00
R_7351_7451 7351 7451 9.830472e+00
R_7451_7551 7451 7551 9.221999e+00
R_7551_7651 7551 7651 5.647983e+00
R_7651_7751 7651 7751 6.303431e+00
R_7751_7851 7751 7851 7.824259e+00
R_7851_7951 7851 7951 8.609213e+00
R_7951_8051 7951 8051 2.818363e+00
R_8051_8151 8051 8151 6.433503e+00
R_8151_8251 8151 8251 8.771052e+00
R_8251_8351 8251 8351 6.442328e+00
R_8351_8451 8351 8451 3.223295e+00
R_8451_8551 8451 8551 9.162107e+00
R_8551_8651 8551 8651 3.662530e+00
R_8651_8751 8651 8751 2.362961e+00
R_8751_8851 8751 8851 6.037374e+00
R_8851_8951 8851 8951 3.300470e+00
R_8951_9051 8951 9051 2.640604e+00
R_9051_9151 9051 9151 9.661914e+00
R_9151_9251 9151 9251 7.332340e+00
R_9251_9351 9251 9351 8.150146e+00
R_9351_9451 9351 9451 7.793168e+00
R_9451_9551 9451 9551 4.335859e+00
R_9551_9651 9551 9651 6.853843e+00
R_9651_9751 9651 9751 2.085312e+00
R_9751_9851 9751 9851 7.654211e+00
R_9851_9951 9851 9951 3.938594e-01
R_52_152 52 152 4.437074e+00
R_152_252 152 252 5.772111e+00
R_252_352 252 352 7.047513e+00
R_352_452 352 452 2.156573e+00
R_452_552 452 552 4.995466e+00
R_552_652 552 652 9.074866e+00
R_652_752 652 752 5.222451e+00
R_752_852 752 852 5.966102e+00
R_852_952 852 952 7.479763e+00
R_952_1052 952 1052 4.380311e+00
R_1052_1152 1052 1152 1.022013e+00
R_1152_1252 1152 1252 1.909473e+00
R_1252_1352 1252 1352 3.424978e+00
R_1352_1452 1352 1452 3.692955e+00
R_1452_1552 1452 1552 8.669353e+00
R_1552_1652 1552 1652 3.768311e+00
R_1652_1752 1652 1752 1.718982e+00
R_1752_1852 1752 1852 7.063741e+00
R_1852_1952 1852 1952 1.236176e+00
R_1952_2052 1952 2052 5.482763e+00
R_2052_2152 2052 2152 3.447260e+00
R_2152_2252 2152 2252 4.821245e+00
R_2252_2352 2252 2352 1.711846e+00
R_2352_2452 2352 2452 8.358450e+00
R_2452_2552 2452 2552 9.955325e+00
R_2552_2652 2552 2652 5.569125e+00
R_2652_2752 2652 2752 1.579241e-01
R_2752_2852 2752 2852 6.728500e+00
R_2852_2952 2852 2952 7.513037e+00
R_2952_3052 2952 3052 2.418409e+00
R_3052_3152 3052 3152 2.015239e+00
R_3152_3252 3152 3252 5.972515e+00
R_3252_3352 3252 3352 7.643455e-01
R_3352_3452 3352 3452 3.029693e+00
R_3452_3552 3452 3552 9.220205e+00
R_3552_3652 3552 3652 1.981399e+00
R_3652_3752 3652 3752 5.434913e+00
R_3752_3852 3752 3852 5.498364e+00
R_3852_3952 3852 3952 4.578632e+00
R_3952_4052 3952 4052 7.032921e+00
R_4052_4152 4052 4152 9.817707e+00
R_4152_4252 4152 4252 9.240902e+00
R_4252_4352 4252 4352 6.803894e+00
R_4352_4452 4352 4452 4.237082e+00
R_4452_4552 4452 4552 2.894573e+00
R_4552_4652 4552 4652 2.611643e+00
R_4652_4752 4652 4752 1.826468e+00
R_4752_4852 4752 4852 7.918270e+00
R_4852_4952 4852 4952 7.363256e+00
R_4952_5052 4952 5052 6.421775e-01
R_5052_5152 5052 5152 3.858291e+00
R_5152_5252 5152 5252 3.262806e+00
R_5252_5352 5252 5352 3.539835e+00
R_5352_5452 5352 5452 6.210824e+00
R_5452_5552 5452 5552 9.516440e+00
R_5552_5652 5552 5652 2.800934e-01
R_5652_5752 5652 5752 8.818316e+00
R_5752_5852 5752 5852 3.254960e+00
R_5852_5952 5852 5952 8.053760e+00
R_5952_6052 5952 6052 9.252973e+00
R_6052_6152 6052 6152 8.322309e-01
R_6152_6252 6152 6252 5.916813e+00
R_6252_6352 6252 6352 3.245131e-01
R_6352_6452 6352 6452 7.302926e+00
R_6452_6552 6452 6552 2.327399e+00
R_6552_6652 6552 6652 2.905343e+00
R_6652_6752 6652 6752 8.426946e+00
R_6752_6852 6752 6852 8.706702e+00
R_6852_6952 6852 6952 3.459913e+00
R_6952_7052 6952 7052 3.216942e+00
R_7052_7152 7052 7152 5.221716e+00
R_7152_7252 7152 7252 3.527636e-01
R_7252_7352 7252 7352 8.047048e+00
R_7352_7452 7352 7452 7.148012e+00
R_7452_7552 7452 7552 5.911586e+00
R_7552_7652 7552 7652 6.901575e+00
R_7652_7752 7652 7752 5.898177e+00
R_7752_7852 7752 7852 6.568872e+00
R_7852_7952 7852 7952 5.520736e+00
R_7952_8052 7952 8052 3.043810e-01
R_8052_8152 8052 8152 3.336867e+00
R_8152_8252 8152 8252 8.466915e+00
R_8252_8352 8252 8352 6.307858e+00
R_8352_8452 8352 8452 9.682387e+00
R_8452_8552 8452 8552 1.314568e+00
R_8552_8652 8552 8652 7.320774e+00
R_8652_8752 8652 8752 6.840111e+00
R_8752_8852 8752 8852 4.048305e+00
R_8852_8952 8852 8952 7.006691e+00
R_8952_9052 8952 9052 8.163129e+00
R_9052_9152 9052 9152 3.576464e+00
R_9152_9252 9152 9252 2.921280e+00
R_9252_9352 9252 9352 5.303969e+00
R_9352_9452 9352 9452 5.158955e+00
R_9452_9552 9452 9552 4.611477e+00
R_9552_9652 9552 9652 9.935977e+00
R_9652_9752 9652 9752 7.172919e-01
R_9752_9852 9752 9852 4.862384e-01
R_9852_9952 9852 9952 3.486545e+00
R_53_153 53 153 6.815757e+00
R_153_253 153 253 2.757662e+00
R_253_353 253 353 3.383565e+00
R_353_453 353 453 3.685299e+00
R_453_553 453 553 1.249423e+00
R_553_653 553 653 5.584199e+00
R_653_753 653 753 1.948578e+00
R_753_853 753 853 5.767660e+00
R_853_953 853 953 5.313392e+00
R_953_1053 953 1053 9.698767e+00
R_1053_1153 1053 1153 5.846047e+00
R_1153_1253 1153 1253 3.802043e-01
R_1253_1353 1253 1353 7.774847e+00
R_1353_1453 1353 1453 4.241106e+00
R_1453_1553 1453 1553 2.509646e+00
R_1553_1653 1553 1653 2.551367e+00
R_1653_1753 1653 1753 9.465734e+00
R_1753_1853 1753 1853 7.702691e+00
R_1853_1953 1853 1953 2.872226e+00
R_1953_2053 1953 2053 9.712463e+00
R_2053_2153 2053 2153 7.599312e+00
R_2153_2253 2153 2253 5.188884e+00
R_2253_2353 2253 2353 1.355278e+00
R_2353_2453 2353 2453 8.034676e+00
R_2453_2553 2453 2553 5.640621e+00
R_2553_2653 2553 2653 6.507755e+00
R_2653_2753 2653 2753 2.115818e-02
R_2753_2853 2753 2853 1.168150e+00
R_2853_2953 2853 2953 1.613585e+00
R_2953_3053 2953 3053 8.560993e+00
R_3053_3153 3053 3153 2.597520e+00
R_3153_3253 3153 3253 6.774128e+00
R_3253_3353 3253 3353 6.296413e+00
R_3353_3453 3353 3453 5.132904e+00
R_3453_3553 3453 3553 4.791195e+00
R_3553_3653 3553 3653 6.489608e+00
R_3653_3753 3653 3753 3.161406e+00
R_3753_3853 3753 3853 7.246833e+00
R_3853_3953 3853 3953 8.356549e+00
R_3953_4053 3953 4053 6.837380e+00
R_4053_4153 4053 4153 6.859687e+00
R_4153_4253 4153 4253 6.926702e+00
R_4253_4353 4253 4353 2.736311e+00
R_4353_4453 4353 4453 9.510652e+00
R_4453_4553 4453 4553 7.580345e+00
R_4553_4653 4553 4653 9.690772e+00
R_4653_4753 4653 4753 2.857297e+00
R_4753_4853 4753 4853 2.596704e+00
R_4853_4953 4853 4953 2.208565e+00
R_4953_5053 4953 5053 7.562532e+00
R_5053_5153 5053 5153 8.519033e+00
R_5153_5253 5153 5253 9.000480e+00
R_5253_5353 5253 5353 5.631271e+00
R_5353_5453 5353 5453 1.102477e+00
R_5453_5553 5453 5553 7.896143e+00
R_5553_5653 5553 5653 8.402484e-01
R_5653_5753 5653 5753 6.118319e+00
R_5753_5853 5753 5853 1.896766e+00
R_5853_5953 5853 5953 9.838193e+00
R_5953_6053 5953 6053 5.643957e+00
R_6053_6153 6053 6153 7.503738e+00
R_6153_6253 6153 6253 2.508095e+00
R_6253_6353 6253 6353 4.998598e+00
R_6353_6453 6353 6453 6.834649e+00
R_6453_6553 6453 6553 6.678866e+00
R_6553_6653 6553 6653 1.637446e+00
R_6653_6753 6653 6753 9.894745e+00
R_6753_6853 6753 6853 4.291812e+00
R_6853_6953 6853 6953 7.087884e+00
R_6953_7053 6953 7053 6.327005e+00
R_7053_7153 7053 7153 8.396932e+00
R_7153_7253 7153 7253 1.449832e+00
R_7253_7353 7253 7353 6.716736e+00
R_7353_7453 7353 7453 7.935857e+00
R_7453_7553 7453 7553 8.533001e+00
R_7553_7653 7553 7653 6.030308e+00
R_7653_7753 7653 7753 7.468980e+00
R_7753_7853 7753 7853 9.676151e+00
R_7853_7953 7853 7953 4.335978e+00
R_7953_8053 7953 8053 9.731483e+00
R_8053_8153 8053 8153 6.683566e+00
R_8153_8253 8153 8253 1.257229e+00
R_8253_8353 8253 8353 5.030623e+00
R_8353_8453 8353 8453 9.056323e+00
R_8453_8553 8453 8553 2.044824e+00
R_8553_8653 8553 8653 3.859178e+00
R_8653_8753 8653 8753 4.424983e+00
R_8753_8853 8753 8853 9.416715e+00
R_8853_8953 8853 8953 2.182450e+00
R_8953_9053 8953 9053 8.849179e+00
R_9053_9153 9053 9153 4.950119e+00
R_9153_9253 9153 9253 8.512984e+00
R_9253_9353 9253 9353 6.955167e+00
R_9353_9453 9353 9453 3.015503e+00
R_9453_9553 9453 9553 8.133466e+00
R_9553_9653 9553 9653 9.508858e+00
R_9653_9753 9653 9753 4.489139e+00
R_9753_9853 9753 9853 4.332722e+00
R_9853_9953 9853 9953 7.663453e+00
R_54_154 54 154 6.646956e+00
R_154_254 154 254 3.085244e+00
R_254_354 254 354 1.762289e+00
R_354_454 354 454 6.359860e+00
R_454_554 454 554 2.155971e+00
R_554_654 554 654 1.471383e+00
R_654_754 654 754 6.488562e+00
R_754_854 754 854 3.736752e+00
R_854_954 854 954 4.656061e+00
R_954_1054 954 1054 6.947932e+00
R_1054_1154 1054 1154 6.173834e+00
R_1154_1254 1154 1254 6.470103e+00
R_1254_1354 1254 1354 5.478415e+00
R_1354_1454 1354 1454 9.230000e+00
R_1454_1554 1454 1554 2.173255e+00
R_1554_1654 1554 1654 1.258695e+00
R_1654_1754 1654 1754 3.415983e+00
R_1754_1854 1754 1854 6.667358e-01
R_1854_1954 1854 1954 9.863721e+00
R_1954_2054 1954 2054 1.342948e+00
R_2054_2154 2054 2154 8.429971e+00
R_2154_2254 2154 2254 8.629107e+00
R_2254_2354 2254 2354 5.802431e+00
R_2354_2454 2354 2454 7.332515e-01
R_2454_2554 2454 2554 8.748345e+00
R_2554_2654 2554 2654 7.195945e+00
R_2654_2754 2654 2754 7.244498e+00
R_2754_2854 2754 2854 3.263019e+00
R_2854_2954 2854 2954 6.486800e+00
R_2954_3054 2954 3054 3.785781e+00
R_3054_3154 3054 3154 6.779751e+00
R_3154_3254 3154 3254 1.971487e+00
R_3254_3354 3254 3354 1.275148e+00
R_3354_3454 3354 3454 7.175961e+00
R_3454_3554 3454 3554 6.897753e+00
R_3554_3654 3554 3654 4.716303e+00
R_3654_3754 3654 3754 3.943847e+00
R_3754_3854 3754 3854 8.207795e+00
R_3854_3954 3854 3954 4.913844e+00
R_3954_4054 3954 4054 3.495449e+00
R_4054_4154 4054 4154 9.145261e+00
R_4154_4254 4154 4254 5.522399e+00
R_4254_4354 4254 4354 5.773612e+00
R_4354_4454 4354 4454 3.148429e+00
R_4454_4554 4454 4554 9.153276e+00
R_4554_4654 4554 4654 8.379529e+00
R_4654_4754 4654 4754 4.418539e-01
R_4754_4854 4754 4854 1.675849e+00
R_4854_4954 4854 4954 9.462374e+00
R_4954_5054 4954 5054 1.583092e+00
R_5054_5154 5054 5154 2.626204e+00
R_5154_5254 5154 5254 4.202821e+00
R_5254_5354 5254 5354 7.809833e+00
R_5354_5454 5354 5454 3.435081e+00
R_5454_5554 5454 5554 5.770984e+00
R_5554_5654 5554 5654 5.307307e+00
R_5654_5754 5654 5754 3.149968e+00
R_5754_5854 5754 5854 9.625397e+00
R_5854_5954 5854 5954 6.522778e+00
R_5954_6054 5954 6054 4.958405e+00
R_6054_6154 6054 6154 5.048638e+00
R_6154_6254 6154 6254 2.660701e-01
R_6254_6354 6254 6354 2.840310e+00
R_6354_6454 6354 6454 4.620169e-01
R_6454_6554 6454 6554 7.282522e+00
R_6554_6654 6554 6654 3.645103e+00
R_6654_6754 6654 6754 3.891412e+00
R_6754_6854 6754 6854 2.175729e+00
R_6854_6954 6854 6954 9.941395e-01
R_6954_7054 6954 7054 5.619088e+00
R_7054_7154 7054 7154 8.461235e+00
R_7154_7254 7154 7254 2.525457e+00
R_7254_7354 7254 7354 1.981278e+00
R_7354_7454 7354 7454 1.284402e+00
R_7454_7554 7454 7554 7.382636e-01
R_7554_7654 7554 7654 9.901935e+00
R_7654_7754 7654 7754 3.944116e+00
R_7754_7854 7754 7854 6.892463e+00
R_7854_7954 7854 7954 2.501401e+00
R_7954_8054 7954 8054 6.685282e+00
R_8054_8154 8054 8154 3.771276e+00
R_8154_8254 8154 8254 3.212258e+00
R_8254_8354 8254 8354 2.825970e+00
R_8354_8454 8354 8454 3.257477e+00
R_8454_8554 8454 8554 8.781873e+00
R_8554_8654 8554 8654 4.056138e+00
R_8654_8754 8654 8754 7.795051e+00
R_8754_8854 8754 8854 7.201058e+00
R_8854_8954 8854 8954 7.162426e+00
R_8954_9054 8954 9054 9.731785e+00
R_9054_9154 9054 9154 6.543210e+00
R_9154_9254 9154 9254 8.099045e+00
R_9254_9354 9254 9354 8.205131e+00
R_9354_9454 9354 9454 9.272409e+00
R_9454_9554 9454 9554 7.350743e+00
R_9554_9654 9554 9654 6.176523e+00
R_9654_9754 9654 9754 5.689499e+00
R_9754_9854 9754 9854 5.480803e+00
R_9854_9954 9854 9954 2.878982e+00
R_55_155 55 155 9.629940e+00
R_155_255 155 255 4.937436e+00
R_255_355 255 355 3.237303e+00
R_355_455 355 455 7.029738e+00
R_455_555 455 555 2.862066e+00
R_555_655 555 655 3.554639e+00
R_655_755 655 755 7.049707e+00
R_755_855 755 855 9.565210e+00
R_855_955 855 955 3.966509e+00
R_955_1055 955 1055 8.884433e+00
R_1055_1155 1055 1155 8.146387e+00
R_1155_1255 1155 1255 2.950692e-01
R_1255_1355 1255 1355 7.068027e+00
R_1355_1455 1355 1455 6.797358e+00
R_1455_1555 1455 1555 5.865527e+00
R_1555_1655 1555 1655 4.237533e+00
R_1655_1755 1655 1755 9.499062e+00
R_1755_1855 1755 1855 7.702700e+00
R_1855_1955 1855 1955 2.015694e+00
R_1955_2055 1955 2055 2.204398e+00
R_2055_2155 2055 2155 8.072987e+00
R_2155_2255 2155 2255 5.117611e+00
R_2255_2355 2255 2355 5.678577e+00
R_2355_2455 2355 2455 3.677740e+00
R_2455_2555 2455 2555 8.778658e+00
R_2555_2655 2555 2655 8.063990e+00
R_2655_2755 2655 2755 1.898067e+00
R_2755_2855 2755 2855 1.063892e+00
R_2855_2955 2855 2955 5.407962e+00
R_2955_3055 2955 3055 9.622708e+00
R_3055_3155 3055 3155 4.268651e-01
R_3155_3255 3155 3255 2.526504e+00
R_3255_3355 3255 3355 6.276829e+00
R_3355_3455 3355 3455 8.823188e+00
R_3455_3555 3455 3555 4.788430e+00
R_3555_3655 3555 3655 6.881047e-02
R_3655_3755 3655 3755 6.827106e-01
R_3755_3855 3755 3855 7.124924e+00
R_3855_3955 3855 3955 5.832224e+00
R_3955_4055 3955 4055 5.749753e+00
R_4055_4155 4055 4155 7.419571e+00
R_4155_4255 4155 4255 2.803978e+00
R_4255_4355 4255 4355 1.637909e+00
R_4355_4455 4355 4455 3.842389e+00
R_4455_4555 4455 4555 4.419826e+00
R_4555_4655 4555 4655 8.286380e+00
R_4655_4755 4655 4755 6.350705e+00
R_4755_4855 4755 4855 8.728754e+00
R_4855_4955 4855 4955 2.305797e+00
R_4955_5055 4955 5055 4.026822e+00
R_5055_5155 5055 5155 6.181487e-01
R_5155_5255 5155 5255 4.619286e+00
R_5255_5355 5255 5355 6.962440e+00
R_5355_5455 5355 5455 9.315561e+00
R_5455_5555 5455 5555 3.552670e+00
R_5555_5655 5555 5655 6.357650e+00
R_5655_5755 5655 5755 9.982346e+00
R_5755_5855 5755 5855 7.640914e+00
R_5855_5955 5855 5955 2.403466e+00
R_5955_6055 5955 6055 8.226029e+00
R_6055_6155 6055 6155 8.336204e+00
R_6155_6255 6155 6255 6.688029e+00
R_6255_6355 6255 6355 7.550171e+00
R_6355_6455 6355 6455 5.662387e-01
R_6455_6555 6455 6555 1.137241e+00
R_6555_6655 6555 6655 2.835394e+00
R_6655_6755 6655 6755 9.422061e+00
R_6755_6855 6755 6855 1.961279e+00
R_6855_6955 6855 6955 4.852636e-02
R_6955_7055 6955 7055 5.106905e+00
R_7055_7155 7055 7155 7.091872e+00
R_7155_7255 7155 7255 2.491218e+00
R_7255_7355 7255 7355 6.607378e+00
R_7355_7455 7355 7455 3.987442e+00
R_7455_7555 7455 7555 1.032820e+00
R_7555_7655 7555 7655 9.255039e+00
R_7655_7755 7655 7755 5.177955e+00
R_7755_7855 7755 7855 4.340039e+00
R_7855_7955 7855 7955 9.033052e+00
R_7955_8055 7955 8055 5.015128e+00
R_8055_8155 8055 8155 8.580505e+00
R_8155_8255 8155 8255 8.863227e+00
R_8255_8355 8255 8355 9.512366e+00
R_8355_8455 8355 8455 9.832407e+00
R_8455_8555 8455 8555 5.569996e+00
R_8555_8655 8555 8655 6.922614e+00
R_8655_8755 8655 8755 2.963230e+00
R_8755_8855 8755 8855 3.013045e+00
R_8855_8955 8855 8955 3.738279e+00
R_8955_9055 8955 9055 1.030343e+00
R_9055_9155 9055 9155 7.888607e+00
R_9155_9255 9155 9255 9.946087e+00
R_9255_9355 9255 9355 6.423469e+00
R_9355_9455 9355 9455 5.768234e+00
R_9455_9555 9455 9555 5.313200e+00
R_9555_9655 9555 9655 1.815769e+00
R_9655_9755 9655 9755 6.983944e+00
R_9755_9855 9755 9855 2.067535e+00
R_9855_9955 9855 9955 3.378948e+00
R_56_156 56 156 8.773628e+00
R_156_256 156 256 3.009049e+00
R_256_356 256 356 2.949066e+00
R_356_456 356 456 6.245877e+00
R_456_556 456 556 3.888301e+00
R_556_656 556 656 1.885238e+00
R_656_756 656 756 6.637681e+00
R_756_856 756 856 8.585163e+00
R_856_956 856 956 5.690259e+00
R_956_1056 956 1056 9.787444e+00
R_1056_1156 1056 1156 2.195964e+00
R_1156_1256 1156 1256 1.112339e+00
R_1256_1356 1256 1356 1.201622e+00
R_1356_1456 1356 1456 8.050249e-02
R_1456_1556 1456 1556 1.653225e+00
R_1556_1656 1556 1656 4.863223e+00
R_1656_1756 1656 1756 1.926637e+00
R_1756_1856 1756 1856 8.314882e+00
R_1856_1956 1856 1956 9.071813e+00
R_1956_2056 1956 2056 4.719583e+00
R_2056_2156 2056 2156 1.901411e+00
R_2156_2256 2156 2256 5.642461e+00
R_2256_2356 2256 2356 8.515037e+00
R_2356_2456 2356 2456 3.436178e+00
R_2456_2556 2456 2556 3.612302e-01
R_2556_2656 2556 2656 5.788990e-02
R_2656_2756 2656 2756 8.907468e-01
R_2756_2856 2756 2856 5.402443e+00
R_2856_2956 2856 2956 8.661672e+00
R_2956_3056 2956 3056 1.705396e+00
R_3056_3156 3056 3156 9.773175e+00
R_3156_3256 3156 3256 6.049204e+00
R_3256_3356 3256 3356 4.765003e+00
R_3356_3456 3356 3456 6.833088e+00
R_3456_3556 3456 3556 9.690630e+00
R_3556_3656 3556 3656 9.611398e+00
R_3656_3756 3656 3756 5.748599e+00
R_3756_3856 3756 3856 5.850870e+00
R_3856_3956 3856 3956 8.460605e+00
R_3956_4056 3956 4056 4.097977e+00
R_4056_4156 4056 4156 2.416078e-02
R_4156_4256 4156 4256 8.575094e+00
R_4256_4356 4256 4356 7.309446e+00
R_4356_4456 4356 4456 9.298388e+00
R_4456_4556 4456 4556 7.491406e+00
R_4556_4656 4556 4656 8.500543e-01
R_4656_4756 4656 4756 4.940359e+00
R_4756_4856 4756 4856 4.271090e+00
R_4856_4956 4856 4956 2.839917e-01
R_4956_5056 4956 5056 2.940901e+00
R_5056_5156 5056 5156 2.695795e+00
R_5156_5256 5156 5256 1.088213e+00
R_5256_5356 5256 5356 7.794814e+00
R_5356_5456 5356 5456 2.735284e+00
R_5456_5556 5456 5556 4.866726e+00
R_5556_5656 5556 5656 9.962689e+00
R_5656_5756 5656 5756 1.207729e+00
R_5756_5856 5756 5856 8.077968e+00
R_5856_5956 5856 5956 6.006410e-01
R_5956_6056 5956 6056 2.771770e+00
R_6056_6156 6056 6156 3.316787e+00
R_6156_6256 6156 6256 6.787246e+00
R_6256_6356 6256 6356 3.385662e+00
R_6356_6456 6356 6456 7.006620e+00
R_6456_6556 6456 6556 2.145294e-01
R_6556_6656 6556 6656 2.542546e+00
R_6656_6756 6656 6756 1.739192e+00
R_6756_6856 6756 6856 2.089773e+00
R_6856_6956 6856 6956 5.287780e+00
R_6956_7056 6956 7056 8.143896e+00
R_7056_7156 7056 7156 5.708430e+00
R_7156_7256 7156 7256 8.302861e+00
R_7256_7356 7256 7356 3.494263e+00
R_7356_7456 7356 7456 5.727852e+00
R_7456_7556 7456 7556 7.492421e+00
R_7556_7656 7556 7656 9.631627e+00
R_7656_7756 7656 7756 3.029447e+00
R_7756_7856 7756 7856 9.803768e+00
R_7856_7956 7856 7956 3.553037e+00
R_7956_8056 7956 8056 8.595385e+00
R_8056_8156 8056 8156 9.348160e+00
R_8156_8256 8156 8256 8.796016e+00
R_8256_8356 8256 8356 8.942384e+00
R_8356_8456 8356 8456 7.744481e+00
R_8456_8556 8456 8556 6.296294e+00
R_8556_8656 8556 8656 1.236192e+00
R_8656_8756 8656 8756 2.461715e+00
R_8756_8856 8756 8856 1.422589e+00
R_8856_8956 8856 8956 8.199614e+00
R_8956_9056 8956 9056 4.832447e+00
R_9056_9156 9056 9156 7.660930e+00
R_9156_9256 9156 9256 8.720298e+00
R_9256_9356 9256 9356 5.869446e+00
R_9356_9456 9356 9456 3.351876e+00
R_9456_9556 9456 9556 3.054563e+00
R_9556_9656 9556 9656 8.424870e+00
R_9656_9756 9656 9756 6.731365e+00
R_9756_9856 9756 9856 7.265846e+00
R_9856_9956 9856 9956 5.156295e+00
R_57_157 57 157 5.550260e+00
R_157_257 157 257 7.691862e+00
R_257_357 257 357 1.046823e+00
R_357_457 357 457 1.982336e-01
R_457_557 457 557 4.398696e-01
R_557_657 557 657 8.756158e+00
R_657_757 657 757 3.507979e+00
R_757_857 757 857 8.465877e+00
R_857_957 857 957 9.393702e+00
R_957_1057 957 1057 8.866986e+00
R_1057_1157 1057 1157 4.314895e+00
R_1157_1257 1157 1257 1.307003e+00
R_1257_1357 1257 1357 2.012509e+00
R_1357_1457 1357 1457 5.860075e+00
R_1457_1557 1457 1557 1.339221e-01
R_1557_1657 1557 1657 5.235628e+00
R_1657_1757 1657 1757 4.524921e+00
R_1757_1857 1757 1857 7.591765e+00
R_1857_1957 1857 1957 1.901881e+00
R_1957_2057 1957 2057 7.356421e+00
R_2057_2157 2057 2157 8.253881e+00
R_2157_2257 2157 2257 2.915546e-01
R_2257_2357 2257 2357 3.677523e+00
R_2357_2457 2357 2457 2.647127e+00
R_2457_2557 2457 2557 1.008275e-01
R_2557_2657 2557 2657 5.485199e+00
R_2657_2757 2657 2757 1.516607e+00
R_2757_2857 2757 2857 9.900241e+00
R_2857_2957 2857 2957 3.894110e+00
R_2957_3057 2957 3057 8.386714e+00
R_3057_3157 3057 3157 6.257499e+00
R_3157_3257 3157 3257 3.982964e+00
R_3257_3357 3257 3357 1.712289e+00
R_3357_3457 3357 3457 2.890214e+00
R_3457_3557 3457 3557 2.648993e+00
R_3557_3657 3557 3657 7.053482e+00
R_3657_3757 3657 3757 9.715978e+00
R_3757_3857 3757 3857 7.631751e+00
R_3857_3957 3857 3957 4.857502e+00
R_3957_4057 3957 4057 6.008854e+00
R_4057_4157 4057 4157 7.198451e+00
R_4157_4257 4157 4257 9.689231e+00
R_4257_4357 4257 4357 4.042264e+00
R_4357_4457 4357 4457 3.102557e+00
R_4457_4557 4457 4557 7.744956e+00
R_4557_4657 4557 4657 7.070253e+00
R_4657_4757 4657 4757 4.874095e+00
R_4757_4857 4757 4857 1.684642e+00
R_4857_4957 4857 4957 4.210250e+00
R_4957_5057 4957 5057 6.249389e+00
R_5057_5157 5057 5157 9.656399e+00
R_5157_5257 5157 5257 3.992358e-01
R_5257_5357 5257 5357 6.012678e+00
R_5357_5457 5357 5457 6.850274e+00
R_5457_5557 5457 5557 8.512394e+00
R_5557_5657 5557 5657 5.026316e-01
R_5657_5757 5657 5757 8.305122e+00
R_5757_5857 5757 5857 4.735023e+00
R_5857_5957 5857 5957 5.247127e+00
R_5957_6057 5957 6057 7.196384e+00
R_6057_6157 6057 6157 6.620362e+00
R_6157_6257 6157 6257 3.530965e+00
R_6257_6357 6257 6357 7.700945e+00
R_6357_6457 6357 6457 8.685189e+00
R_6457_6557 6457 6557 9.853569e+00
R_6557_6657 6557 6657 5.903846e+00
R_6657_6757 6657 6757 8.630565e+00
R_6757_6857 6757 6857 7.856219e+00
R_6857_6957 6857 6957 5.231633e+00
R_6957_7057 6957 7057 1.379153e-01
R_7057_7157 7057 7157 6.472337e-01
R_7157_7257 7157 7257 1.360603e+00
R_7257_7357 7257 7357 2.175172e+00
R_7357_7457 7357 7457 5.365174e+00
R_7457_7557 7457 7557 1.187547e+00
R_7557_7657 7557 7657 8.291493e+00
R_7657_7757 7657 7757 2.970662e+00
R_7757_7857 7757 7857 4.962034e-01
R_7857_7957 7857 7957 5.467727e+00
R_7957_8057 7957 8057 9.522389e+00
R_8057_8157 8057 8157 3.089857e+00
R_8157_8257 8157 8257 8.125940e+00
R_8257_8357 8257 8357 2.840689e+00
R_8357_8457 8357 8457 7.266256e+00
R_8457_8557 8457 8557 8.095156e+00
R_8557_8657 8557 8657 6.023989e+00
R_8657_8757 8657 8757 3.312755e+00
R_8757_8857 8757 8857 7.971828e+00
R_8857_8957 8857 8957 1.573667e+00
R_8957_9057 8957 9057 1.750269e+00
R_9057_9157 9057 9157 1.076558e+00
R_9157_9257 9157 9257 4.068688e+00
R_9257_9357 9257 9357 6.977379e+00
R_9357_9457 9357 9457 4.281920e+00
R_9457_9557 9457 9557 7.504248e+00
R_9557_9657 9557 9657 9.097770e-01
R_9657_9757 9657 9757 4.051109e+00
R_9757_9857 9757 9857 1.492633e+00
R_9857_9957 9857 9957 6.836720e+00
R_58_158 58 158 8.193209e+00
R_158_258 158 258 2.574297e+00
R_258_358 258 358 9.435150e+00
R_358_458 358 458 5.059940e+00
R_458_558 458 558 2.680461e+00
R_558_658 558 658 8.037640e+00
R_658_758 658 758 6.685285e+00
R_758_858 758 858 3.756666e+00
R_858_958 858 958 3.488573e+00
R_958_1058 958 1058 8.217954e+00
R_1058_1158 1058 1158 8.547566e+00
R_1158_1258 1158 1258 2.014704e+00
R_1258_1358 1258 1358 7.340490e+00
R_1358_1458 1358 1458 5.408512e+00
R_1458_1558 1458 1558 1.706088e+00
R_1558_1658 1558 1658 7.358503e+00
R_1658_1758 1658 1758 8.692792e+00
R_1758_1858 1758 1858 6.371056e+00
R_1858_1958 1858 1958 2.458513e+00
R_1958_2058 1958 2058 4.140929e+00
R_2058_2158 2058 2158 1.268608e+00
R_2158_2258 2158 2258 7.253260e+00
R_2258_2358 2258 2358 6.562842e+00
R_2358_2458 2358 2458 9.246353e+00
R_2458_2558 2458 2558 4.203716e+00
R_2558_2658 2558 2658 7.743176e+00
R_2658_2758 2658 2758 9.647687e-02
R_2758_2858 2758 2858 7.982423e+00
R_2858_2958 2858 2958 6.266346e+00
R_2958_3058 2958 3058 5.161877e+00
R_3058_3158 3058 3158 7.112349e+00
R_3158_3258 3158 3258 4.703837e+00
R_3258_3358 3258 3358 7.755956e+00
R_3358_3458 3358 3458 2.644547e+00
R_3458_3558 3458 3558 2.868238e+00
R_3558_3658 3558 3658 9.665837e+00
R_3658_3758 3658 3758 6.493250e+00
R_3758_3858 3758 3858 6.059709e+00
R_3858_3958 3858 3958 9.281937e+00
R_3958_4058 3958 4058 9.374227e+00
R_4058_4158 4058 4158 3.111978e+00
R_4158_4258 4158 4258 9.141075e+00
R_4258_4358 4258 4358 1.271941e+00
R_4358_4458 4358 4458 1.214004e+00
R_4458_4558 4458 4558 6.545594e+00
R_4558_4658 4558 4658 5.331712e+00
R_4658_4758 4658 4758 7.773875e+00
R_4758_4858 4758 4858 6.830789e+00
R_4858_4958 4858 4958 8.399420e-01
R_4958_5058 4958 5058 2.864367e+00
R_5058_5158 5058 5158 8.296673e+00
R_5158_5258 5158 5258 6.008114e+00
R_5258_5358 5258 5358 2.005494e+00
R_5358_5458 5358 5458 5.676727e+00
R_5458_5558 5458 5558 5.916241e+00
R_5558_5658 5558 5658 1.180290e+00
R_5658_5758 5658 5758 2.484237e+00
R_5758_5858 5758 5858 4.655662e+00
R_5858_5958 5858 5958 1.625467e+00
R_5958_6058 5958 6058 4.519201e+00
R_6058_6158 6058 6158 8.456587e+00
R_6158_6258 6158 6258 1.909925e+00
R_6258_6358 6258 6358 4.194862e+00
R_6358_6458 6358 6458 7.393900e+00
R_6458_6558 6458 6558 6.627906e-01
R_6558_6658 6558 6658 2.018729e-01
R_6658_6758 6658 6758 7.726830e+00
R_6758_6858 6758 6858 4.204022e-01
R_6858_6958 6858 6958 3.149640e+00
R_6958_7058 6958 7058 1.957412e-01
R_7058_7158 7058 7158 3.867308e+00
R_7158_7258 7158 7258 4.487021e+00
R_7258_7358 7258 7358 9.130159e+00
R_7358_7458 7358 7458 6.016893e+00
R_7458_7558 7458 7558 3.354812e+00
R_7558_7658 7558 7658 2.082724e+00
R_7658_7758 7658 7758 8.002497e+00
R_7758_7858 7758 7858 8.525884e+00
R_7858_7958 7858 7958 6.070247e+00
R_7958_8058 7958 8058 3.167423e+00
R_8058_8158 8058 8158 5.005199e+00
R_8158_8258 8158 8258 7.420565e+00
R_8258_8358 8258 8358 1.107133e+00
R_8358_8458 8358 8458 1.123879e+00
R_8458_8558 8458 8558 9.811024e+00
R_8558_8658 8558 8658 1.411566e+00
R_8658_8758 8658 8758 1.149790e+00
R_8758_8858 8758 8858 5.842431e+00
R_8858_8958 8858 8958 7.474464e+00
R_8958_9058 8958 9058 9.148729e+00
R_9058_9158 9058 9158 4.579057e+00
R_9158_9258 9158 9258 8.979915e+00
R_9258_9358 9258 9358 3.005459e-04
R_9358_9458 9358 9458 4.030463e+00
R_9458_9558 9458 9558 6.187916e+00
R_9558_9658 9558 9658 2.208988e+00
R_9658_9758 9658 9758 9.737146e-01
R_9758_9858 9758 9858 7.722248e+00
R_9858_9958 9858 9958 1.322022e+00
R_59_159 59 159 3.475863e+00
R_159_259 159 259 6.600497e+00
R_259_359 259 359 7.494225e+00
R_359_459 359 459 7.237358e+00
R_459_559 459 559 2.762741e+00
R_559_659 559 659 1.122205e+00
R_659_759 659 759 9.815887e+00
R_759_859 759 859 5.077328e+00
R_859_959 859 959 7.070921e+00
R_959_1059 959 1059 8.522765e+00
R_1059_1159 1059 1159 2.191310e+00
R_1159_1259 1159 1259 7.768576e+00
R_1259_1359 1259 1359 9.350880e-01
R_1359_1459 1359 1459 9.102207e+00
R_1459_1559 1459 1559 7.533600e+00
R_1559_1659 1559 1659 2.386070e+00
R_1659_1759 1659 1759 6.396962e+00
R_1759_1859 1759 1859 2.456282e+00
R_1859_1959 1859 1959 5.920547e+00
R_1959_2059 1959 2059 9.853346e+00
R_2059_2159 2059 2159 4.891570e-01
R_2159_2259 2159 2259 7.316956e+00
R_2259_2359 2259 2359 3.213346e+00
R_2359_2459 2359 2459 8.936314e+00
R_2459_2559 2459 2559 6.133112e+00
R_2559_2659 2559 2659 8.663847e+00
R_2659_2759 2659 2759 7.686513e+00
R_2759_2859 2759 2859 4.195683e-02
R_2859_2959 2859 2959 3.784599e+00
R_2959_3059 2959 3059 2.639499e+00
R_3059_3159 3059 3159 1.324761e+00
R_3159_3259 3159 3259 3.885881e+00
R_3259_3359 3259 3359 9.372164e+00
R_3359_3459 3359 3459 3.067458e+00
R_3459_3559 3459 3559 9.095872e+00
R_3559_3659 3559 3659 8.994419e+00
R_3659_3759 3659 3759 3.458631e-01
R_3759_3859 3759 3859 6.857526e+00
R_3859_3959 3859 3959 2.440250e+00
R_3959_4059 3959 4059 5.802249e+00
R_4059_4159 4059 4159 6.986783e+00
R_4159_4259 4159 4259 3.751896e+00
R_4259_4359 4259 4359 3.376977e+00
R_4359_4459 4359 4459 3.635591e+00
R_4459_4559 4459 4559 1.839942e+00
R_4559_4659 4559 4659 6.967967e+00
R_4659_4759 4659 4759 6.749229e+00
R_4759_4859 4759 4859 7.069488e+00
R_4859_4959 4859 4959 1.441709e-01
R_4959_5059 4959 5059 4.497134e+00
R_5059_5159 5059 5159 4.350901e+00
R_5159_5259 5159 5259 5.050630e+00
R_5259_5359 5259 5359 2.100091e+00
R_5359_5459 5359 5459 5.425588e+00
R_5459_5559 5459 5559 2.332671e+00
R_5559_5659 5559 5659 5.018608e+00
R_5659_5759 5659 5759 4.098085e-01
R_5759_5859 5759 5859 8.288107e+00
R_5859_5959 5859 5959 4.016849e+00
R_5959_6059 5959 6059 5.795007e+00
R_6059_6159 6059 6159 5.285498e+00
R_6159_6259 6159 6259 1.196870e-01
R_6259_6359 6259 6359 6.432510e+00
R_6359_6459 6359 6459 1.427584e+00
R_6459_6559 6459 6559 6.520520e+00
R_6559_6659 6559 6659 9.910814e+00
R_6659_6759 6659 6759 7.116206e+00
R_6759_6859 6759 6859 9.454441e+00
R_6859_6959 6859 6959 3.619238e+00
R_6959_7059 6959 7059 7.362249e+00
R_7059_7159 7059 7159 2.653407e+00
R_7159_7259 7159 7259 7.700113e+00
R_7259_7359 7259 7359 9.101152e+00
R_7359_7459 7359 7459 7.016854e+00
R_7459_7559 7459 7559 4.561752e+00
R_7559_7659 7559 7659 5.235239e-01
R_7659_7759 7659 7759 1.477747e+00
R_7759_7859 7759 7859 3.888247e+00
R_7859_7959 7859 7959 6.869637e+00
R_7959_8059 7959 8059 6.125393e+00
R_8059_8159 8059 8159 1.612439e+00
R_8159_8259 8159 8259 5.204186e+00
R_8259_8359 8259 8359 4.911324e+00
R_8359_8459 8359 8459 7.458167e+00
R_8459_8559 8459 8559 2.033261e+00
R_8559_8659 8559 8659 5.772109e-01
R_8659_8759 8659 8759 6.061670e-01
R_8759_8859 8759 8859 2.584806e+00
R_8859_8959 8859 8959 1.528360e+00
R_8959_9059 8959 9059 9.438971e+00
R_9059_9159 9059 9159 7.678703e+00
R_9159_9259 9159 9259 1.995493e+00
R_9259_9359 9259 9359 6.168926e+00
R_9359_9459 9359 9459 8.141364e+00
R_9459_9559 9459 9559 2.998060e+00
R_9559_9659 9559 9659 9.145513e+00
R_9659_9759 9659 9759 4.413394e+00
R_9759_9859 9759 9859 4.923916e+00
R_9859_9959 9859 9959 5.329107e+00
R_60_160 60 160 7.799060e-01
R_160_260 160 260 1.921738e-01
R_260_360 260 360 6.782288e+00
R_360_460 360 460 8.552654e+00
R_460_560 460 560 4.908410e+00
R_560_660 560 660 4.363181e+00
R_660_760 660 760 4.344127e+00
R_760_860 760 860 6.079583e+00
R_860_960 860 960 4.947766e+00
R_960_1060 960 1060 5.106375e+00
R_1060_1160 1060 1160 3.373562e+00
R_1160_1260 1160 1260 1.428261e+00
R_1260_1360 1260 1360 5.472055e+00
R_1360_1460 1360 1460 4.674102e+00
R_1460_1560 1460 1560 8.826106e+00
R_1560_1660 1560 1660 4.834450e+00
R_1660_1760 1660 1760 8.662855e+00
R_1760_1860 1760 1860 3.788265e+00
R_1860_1960 1860 1960 8.927603e+00
R_1960_2060 1960 2060 5.074560e-01
R_2060_2160 2060 2160 6.053609e+00
R_2160_2260 2160 2260 5.786113e+00
R_2260_2360 2260 2360 9.696388e+00
R_2360_2460 2360 2460 9.522864e+00
R_2460_2560 2460 2560 7.418645e+00
R_2560_2660 2560 2660 5.257025e+00
R_2660_2760 2660 2760 9.145393e+00
R_2760_2860 2760 2860 6.835679e+00
R_2860_2960 2860 2960 8.134568e+00
R_2960_3060 2960 3060 3.519164e+00
R_3060_3160 3060 3160 5.923128e+00
R_3160_3260 3160 3260 7.557861e+00
R_3260_3360 3260 3360 6.162144e+00
R_3360_3460 3360 3460 4.590759e+00
R_3460_3560 3460 3560 7.635442e-01
R_3560_3660 3560 3660 7.888371e+00
R_3660_3760 3660 3760 9.706621e+00
R_3760_3860 3760 3860 9.105291e+00
R_3860_3960 3860 3960 2.969550e+00
R_3960_4060 3960 4060 7.696634e+00
R_4060_4160 4060 4160 3.249057e+00
R_4160_4260 4160 4260 7.193400e+00
R_4260_4360 4260 4360 5.657657e+00
R_4360_4460 4360 4460 2.642812e+00
R_4460_4560 4460 4560 7.238772e+00
R_4560_4660 4560 4660 3.977523e+00
R_4660_4760 4660 4760 2.286384e+00
R_4760_4860 4760 4860 4.166784e+00
R_4860_4960 4860 4960 7.550285e+00
R_4960_5060 4960 5060 5.810224e+00
R_5060_5160 5060 5160 6.196827e+00
R_5160_5260 5160 5260 9.835262e+00
R_5260_5360 5260 5360 2.455729e+00
R_5360_5460 5360 5460 4.695809e+00
R_5460_5560 5460 5560 4.213426e+00
R_5560_5660 5560 5660 9.865817e+00
R_5660_5760 5660 5760 5.101193e-02
R_5760_5860 5760 5860 4.957573e+00
R_5860_5960 5860 5960 3.909112e+00
R_5960_6060 5960 6060 7.027981e+00
R_6060_6160 6060 6160 8.413766e-01
R_6160_6260 6160 6260 8.033840e+00
R_6260_6360 6260 6360 7.854599e+00
R_6360_6460 6360 6460 7.081747e+00
R_6460_6560 6460 6560 9.725302e+00
R_6560_6660 6560 6660 3.403742e+00
R_6660_6760 6660 6760 3.866107e+00
R_6760_6860 6760 6860 8.492400e+00
R_6860_6960 6860 6960 4.998855e+00
R_6960_7060 6960 7060 5.270247e+00
R_7060_7160 7060 7160 7.566949e+00
R_7160_7260 7160 7260 1.059097e+00
R_7260_7360 7260 7360 2.317243e-01
R_7360_7460 7360 7460 6.727574e+00
R_7460_7560 7460 7560 9.421271e+00
R_7560_7660 7560 7660 7.249169e-01
R_7660_7760 7660 7760 3.579128e-01
R_7760_7860 7760 7860 2.732365e+00
R_7860_7960 7860 7960 5.489608e+00
R_7960_8060 7960 8060 7.740790e+00
R_8060_8160 8060 8160 4.025472e+00
R_8160_8260 8160 8260 1.823482e+00
R_8260_8360 8260 8360 3.821793e+00
R_8360_8460 8360 8460 5.672886e+00
R_8460_8560 8460 8560 9.891344e+00
R_8560_8660 8560 8660 3.608332e+00
R_8660_8760 8660 8760 9.947236e+00
R_8760_8860 8760 8860 7.186459e+00
R_8860_8960 8860 8960 6.505536e+00
R_8960_9060 8960 9060 6.223258e+00
R_9060_9160 9060 9160 2.375616e+00
R_9160_9260 9160 9260 2.246919e+00
R_9260_9360 9260 9360 7.528000e+00
R_9360_9460 9360 9460 1.131187e+00
R_9460_9560 9460 9560 9.954479e-01
R_9560_9660 9560 9660 3.589686e+00
R_9660_9760 9660 9760 5.234931e+00
R_9760_9860 9760 9860 5.356232e+00
R_9860_9960 9860 9960 2.794800e-01
R_61_161 61 161 9.792915e+00
R_161_261 161 261 9.636088e-01
R_261_361 261 361 8.256663e+00
R_361_461 361 461 8.646407e+00
R_461_561 461 561 1.770681e+00
R_561_661 561 661 3.374520e+00
R_661_761 661 761 8.679006e+00
R_761_861 761 861 3.317159e+00
R_861_961 861 961 2.393805e+00
R_961_1061 961 1061 9.739815e+00
R_1061_1161 1061 1161 3.245385e+00
R_1161_1261 1161 1261 3.544575e+00
R_1261_1361 1261 1361 1.935149e+00
R_1361_1461 1361 1461 8.496295e+00
R_1461_1561 1461 1561 5.161545e+00
R_1561_1661 1561 1661 5.170654e+00
R_1661_1761 1661 1761 9.731639e+00
R_1761_1861 1761 1861 9.754728e+00
R_1861_1961 1861 1961 7.905858e+00
R_1961_2061 1961 2061 7.852755e+00
R_2061_2161 2061 2161 3.990435e-01
R_2161_2261 2161 2261 9.631101e+00
R_2261_2361 2261 2361 5.476651e+00
R_2361_2461 2361 2461 4.917130e+00
R_2461_2561 2461 2561 5.505982e+00
R_2561_2661 2561 2661 4.063078e+00
R_2661_2761 2661 2761 8.332748e+00
R_2761_2861 2761 2861 8.071391e+00
R_2861_2961 2861 2961 1.952013e+00
R_2961_3061 2961 3061 5.616596e+00
R_3061_3161 3061 3161 9.056920e+00
R_3161_3261 3161 3261 8.199314e+00
R_3261_3361 3261 3361 4.572058e+00
R_3361_3461 3361 3461 9.646328e+00
R_3461_3561 3461 3561 1.544731e+00
R_3561_3661 3561 3661 5.087967e+00
R_3661_3761 3661 3761 7.392229e+00
R_3761_3861 3761 3861 4.894705e+00
R_3861_3961 3861 3961 4.919995e+00
R_3961_4061 3961 4061 3.981850e+00
R_4061_4161 4061 4161 7.653630e+00
R_4161_4261 4161 4261 3.283221e+00
R_4261_4361 4261 4361 7.026475e+00
R_4361_4461 4361 4461 6.587476e+00
R_4461_4561 4461 4561 3.462577e+00
R_4561_4661 4561 4661 9.617039e+00
R_4661_4761 4661 4761 1.096059e+00
R_4761_4861 4761 4861 3.748018e+00
R_4861_4961 4861 4961 8.143245e+00
R_4961_5061 4961 5061 5.755200e+00
R_5061_5161 5061 5161 7.540786e-01
R_5161_5261 5161 5261 8.099190e+00
R_5261_5361 5261 5361 5.610292e+00
R_5361_5461 5361 5461 8.174863e+00
R_5461_5561 5461 5561 6.709589e+00
R_5561_5661 5561 5661 6.550869e+00
R_5661_5761 5661 5761 2.340282e-01
R_5761_5861 5761 5861 4.375471e+00
R_5861_5961 5861 5961 1.775617e+00
R_5961_6061 5961 6061 4.335902e+00
R_6061_6161 6061 6161 1.635808e+00
R_6161_6261 6161 6261 3.553373e+00
R_6261_6361 6261 6361 1.028649e+00
R_6361_6461 6361 6461 3.334565e-01
R_6461_6561 6461 6561 7.746162e+00
R_6561_6661 6561 6661 6.145568e+00
R_6661_6761 6661 6761 5.322202e+00
R_6761_6861 6761 6861 2.986629e+00
R_6861_6961 6861 6961 7.716514e+00
R_6961_7061 6961 7061 2.938652e+00
R_7061_7161 7061 7161 1.547926e+00
R_7161_7261 7161 7261 6.826018e+00
R_7261_7361 7261 7361 9.544111e+00
R_7361_7461 7361 7461 9.897600e+00
R_7461_7561 7461 7561 6.548106e+00
R_7561_7661 7561 7661 6.894966e+00
R_7661_7761 7661 7761 1.714568e+00
R_7761_7861 7761 7861 5.762590e+00
R_7861_7961 7861 7961 5.868231e+00
R_7961_8061 7961 8061 2.684866e+00
R_8061_8161 8061 8161 4.854367e+00
R_8161_8261 8161 8261 7.702118e-01
R_8261_8361 8261 8361 1.180243e+00
R_8361_8461 8361 8461 9.704677e-01
R_8461_8561 8461 8561 7.002295e+00
R_8561_8661 8561 8661 1.589160e+00
R_8661_8761 8661 8761 9.876577e+00
R_8761_8861 8761 8861 4.038779e+00
R_8861_8961 8861 8961 2.537964e+00
R_8961_9061 8961 9061 5.270815e+00
R_9061_9161 9061 9161 2.706722e+00
R_9161_9261 9161 9261 9.196883e-01
R_9261_9361 9261 9361 4.281904e+00
R_9361_9461 9361 9461 2.454394e+00
R_9461_9561 9461 9561 6.870043e+00
R_9561_9661 9561 9661 7.261777e+00
R_9661_9761 9661 9761 6.764342e+00
R_9761_9861 9761 9861 1.493500e+00
R_9861_9961 9861 9961 9.516847e+00
R_62_162 62 162 7.900794e-01
R_162_262 162 262 8.190823e+00
R_262_362 262 362 3.401098e+00
R_362_462 362 462 2.226642e+00
R_462_562 462 562 3.834971e+00
R_562_662 562 662 8.729055e+00
R_662_762 662 762 9.471313e+00
R_762_862 762 862 3.742132e+00
R_862_962 862 962 6.440328e+00
R_962_1062 962 1062 8.988983e+00
R_1062_1162 1062 1162 4.650258e-01
R_1162_1262 1162 1262 4.528367e+00
R_1262_1362 1262 1362 9.780758e+00
R_1362_1462 1362 1462 2.313008e+00
R_1462_1562 1462 1562 3.218146e-01
R_1562_1662 1562 1662 5.424639e+00
R_1662_1762 1662 1762 7.665233e+00
R_1762_1862 1762 1862 4.557085e+00
R_1862_1962 1862 1962 8.199715e+00
R_1962_2062 1962 2062 2.840362e+00
R_2062_2162 2062 2162 5.125178e+00
R_2162_2262 2162 2262 4.237951e+00
R_2262_2362 2262 2362 4.959861e+00
R_2362_2462 2362 2462 6.034193e-02
R_2462_2562 2462 2562 5.964256e+00
R_2562_2662 2562 2662 1.122716e+00
R_2662_2762 2662 2762 4.709502e+00
R_2762_2862 2762 2862 1.524715e+00
R_2862_2962 2862 2962 4.676314e+00
R_2962_3062 2962 3062 3.786172e+00
R_3062_3162 3062 3162 8.296675e+00
R_3162_3262 3162 3262 7.891551e+00
R_3262_3362 3262 3362 7.740185e+00
R_3362_3462 3362 3462 5.675342e+00
R_3462_3562 3462 3562 4.917111e+00
R_3562_3662 3562 3662 4.746752e+00
R_3662_3762 3662 3762 9.676520e+00
R_3762_3862 3762 3862 7.577242e+00
R_3862_3962 3862 3962 7.353212e+00
R_3962_4062 3962 4062 7.789094e+00
R_4062_4162 4062 4162 8.807924e+00
R_4162_4262 4162 4262 6.786090e+00
R_4262_4362 4262 4362 9.030367e+00
R_4362_4462 4362 4462 1.309558e+00
R_4462_4562 4462 4562 1.465131e-01
R_4562_4662 4562 4662 3.345994e+00
R_4662_4762 4662 4762 1.971401e+00
R_4762_4862 4762 4862 4.686064e+00
R_4862_4962 4862 4962 3.754142e+00
R_4962_5062 4962 5062 2.456796e+00
R_5062_5162 5062 5162 8.235643e+00
R_5162_5262 5162 5262 4.813126e+00
R_5262_5362 5262 5362 5.137911e+00
R_5362_5462 5362 5462 1.302717e+00
R_5462_5562 5462 5562 3.998989e+00
R_5562_5662 5562 5662 2.042003e+00
R_5662_5762 5662 5762 7.125216e+00
R_5762_5862 5762 5862 1.461086e-02
R_5862_5962 5862 5962 8.096752e+00
R_5962_6062 5962 6062 8.865970e+00
R_6062_6162 6062 6162 9.538866e+00
R_6162_6262 6162 6262 5.845951e+00
R_6262_6362 6262 6362 8.435409e+00
R_6362_6462 6362 6462 6.352185e+00
R_6462_6562 6462 6562 4.856997e-01
R_6562_6662 6562 6662 6.804928e+00
R_6662_6762 6662 6762 8.572191e+00
R_6762_6862 6762 6862 9.062692e+00
R_6862_6962 6862 6962 5.935990e+00
R_6962_7062 6962 7062 2.071276e+00
R_7062_7162 7062 7162 1.080395e+00
R_7162_7262 7162 7262 9.755266e+00
R_7262_7362 7262 7362 6.958130e-01
R_7362_7462 7362 7462 1.506861e+00
R_7462_7562 7462 7562 2.233495e+00
R_7562_7662 7562 7662 6.111677e+00
R_7662_7762 7662 7762 5.856287e+00
R_7762_7862 7762 7862 8.989260e+00
R_7862_7962 7862 7962 2.236620e-01
R_7962_8062 7962 8062 1.739337e+00
R_8062_8162 8062 8162 1.739741e+00
R_8162_8262 8162 8262 2.120064e+00
R_8262_8362 8262 8362 9.320983e+00
R_8362_8462 8362 8462 9.126803e-02
R_8462_8562 8462 8562 4.078391e+00
R_8562_8662 8562 8662 1.820966e+00
R_8662_8762 8662 8762 7.920907e+00
R_8762_8862 8762 8862 1.965462e+00
R_8862_8962 8862 8962 7.859052e+00
R_8962_9062 8962 9062 7.089862e+00
R_9062_9162 9062 9162 1.358621e+00
R_9162_9262 9162 9262 8.883357e+00
R_9262_9362 9262 9362 5.223137e+00
R_9362_9462 9362 9462 1.416584e+00
R_9462_9562 9462 9562 4.035523e+00
R_9562_9662 9562 9662 2.643978e+00
R_9662_9762 9662 9762 7.846014e+00
R_9762_9862 9762 9862 9.449411e+00
R_9862_9962 9862 9962 4.178429e+00
R_63_163 63 163 3.173312e+00
R_163_263 163 263 9.458576e+00
R_263_363 263 363 8.346530e+00
R_363_463 363 463 5.699774e+00
R_463_563 463 563 9.466625e+00
R_563_663 563 663 8.382291e-01
R_663_763 663 763 7.080047e+00
R_763_863 763 863 7.575624e+00
R_863_963 863 963 1.138741e+00
R_963_1063 963 1063 6.470251e+00
R_1063_1163 1063 1163 2.418764e+00
R_1163_1263 1163 1263 2.264556e+00
R_1263_1363 1263 1363 7.110117e+00
R_1363_1463 1363 1463 8.032954e+00
R_1463_1563 1463 1563 7.857279e+00
R_1563_1663 1563 1663 9.960023e+00
R_1663_1763 1663 1763 6.058563e+00
R_1763_1863 1763 1863 2.357409e+00
R_1863_1963 1863 1963 6.155322e+00
R_1963_2063 1963 2063 2.348961e+00
R_2063_2163 2063 2163 9.798749e-01
R_2163_2263 2163 2263 2.833821e+00
R_2263_2363 2263 2363 9.874881e+00
R_2363_2463 2363 2463 5.541963e+00
R_2463_2563 2463 2563 2.942254e+00
R_2563_2663 2563 2663 5.799122e+00
R_2663_2763 2663 2763 3.895987e+00
R_2763_2863 2763 2863 2.523371e+00
R_2863_2963 2863 2963 4.521692e+00
R_2963_3063 2963 3063 5.717814e+00
R_3063_3163 3063 3163 2.704811e+00
R_3163_3263 3163 3263 3.929057e+00
R_3263_3363 3263 3363 7.263838e+00
R_3363_3463 3363 3463 8.380894e+00
R_3463_3563 3463 3563 9.864577e+00
R_3563_3663 3563 3663 6.027086e+00
R_3663_3763 3663 3763 2.474052e+00
R_3763_3863 3763 3863 9.118935e+00
R_3863_3963 3863 3963 4.240045e+00
R_3963_4063 3963 4063 5.994536e+00
R_4063_4163 4063 4163 4.717377e+00
R_4163_4263 4163 4263 8.962911e+00
R_4263_4363 4263 4363 9.056318e+00
R_4363_4463 4363 4463 8.415430e+00
R_4463_4563 4463 4563 2.523561e-01
R_4563_4663 4563 4663 3.774578e+00
R_4663_4763 4663 4763 7.585233e+00
R_4763_4863 4763 4863 5.103571e+00
R_4863_4963 4863 4963 1.398461e+00
R_4963_5063 4963 5063 7.182690e+00
R_5063_5163 5063 5163 8.951846e+00
R_5163_5263 5163 5263 7.234971e+00
R_5263_5363 5263 5363 9.792190e+00
R_5363_5463 5363 5463 4.586078e-01
R_5463_5563 5463 5563 5.410696e+00
R_5563_5663 5563 5663 9.989208e+00
R_5663_5763 5663 5763 3.642237e+00
R_5763_5863 5763 5863 6.156316e+00
R_5863_5963 5863 5963 2.461787e+00
R_5963_6063 5963 6063 4.940775e+00
R_6063_6163 6063 6163 6.429730e+00
R_6163_6263 6163 6263 1.054734e+00
R_6263_6363 6263 6363 4.137312e+00
R_6363_6463 6363 6463 9.512471e+00
R_6463_6563 6463 6563 7.777402e+00
R_6563_6663 6563 6663 2.470322e-01
R_6663_6763 6663 6763 2.107643e+00
R_6763_6863 6763 6863 8.148543e+00
R_6863_6963 6863 6963 3.429157e+00
R_6963_7063 6963 7063 4.052245e+00
R_7063_7163 7063 7163 5.423981e-01
R_7163_7263 7163 7263 3.482640e+00
R_7263_7363 7263 7363 2.679251e+00
R_7363_7463 7363 7463 9.277409e+00
R_7463_7563 7463 7563 4.522725e+00
R_7563_7663 7563 7663 2.628574e+00
R_7663_7763 7663 7763 1.099442e+00
R_7763_7863 7763 7863 3.847952e+00
R_7863_7963 7863 7963 2.199263e+00
R_7963_8063 7963 8063 9.628236e+00
R_8063_8163 8063 8163 1.934191e+00
R_8163_8263 8163 8263 7.808705e+00
R_8263_8363 8263 8363 5.111236e+00
R_8363_8463 8363 8463 8.488166e+00
R_8463_8563 8463 8563 4.457808e+00
R_8563_8663 8563 8663 5.185070e+00
R_8663_8763 8663 8763 8.187961e-01
R_8763_8863 8763 8863 4.755670e+00
R_8863_8963 8863 8963 6.792830e+00
R_8963_9063 8963 9063 5.016905e-01
R_9063_9163 9063 9163 4.979274e-02
R_9163_9263 9163 9263 6.954539e+00
R_9263_9363 9263 9363 9.032729e+00
R_9363_9463 9363 9463 4.752017e+00
R_9463_9563 9463 9563 2.607722e+00
R_9563_9663 9563 9663 5.768487e+00
R_9663_9763 9663 9763 7.958970e+00
R_9763_9863 9763 9863 3.637126e+00
R_9863_9963 9863 9963 3.239122e+00
R_64_164 64 164 4.735622e+00
R_164_264 164 264 5.097631e+00
R_264_364 264 364 6.437160e+00
R_364_464 364 464 2.676042e-01
R_464_564 464 564 1.161449e+00
R_564_664 564 664 1.431424e+00
R_664_764 664 764 2.771363e+00
R_764_864 764 864 5.865759e+00
R_864_964 864 964 2.025067e+00
R_964_1064 964 1064 1.519995e+00
R_1064_1164 1064 1164 8.439250e-01
R_1164_1264 1164 1264 8.959164e+00
R_1264_1364 1264 1364 9.799517e+00
R_1364_1464 1364 1464 5.372810e+00
R_1464_1564 1464 1564 4.925423e+00
R_1564_1664 1564 1664 5.667419e+00
R_1664_1764 1664 1764 2.546204e+00
R_1764_1864 1764 1864 5.693196e-01
R_1864_1964 1864 1964 4.374821e+00
R_1964_2064 1964 2064 4.316500e+00
R_2064_2164 2064 2164 5.899146e+00
R_2164_2264 2164 2264 3.702925e+00
R_2264_2364 2264 2364 8.435423e+00
R_2364_2464 2364 2464 8.422551e+00
R_2464_2564 2464 2564 1.469438e-01
R_2564_2664 2564 2664 2.467987e+00
R_2664_2764 2664 2764 7.106215e+00
R_2764_2864 2764 2864 9.565797e+00
R_2864_2964 2864 2964 3.517509e-01
R_2964_3064 2964 3064 7.161046e+00
R_3064_3164 3064 3164 5.776942e+00
R_3164_3264 3164 3264 6.586474e+00
R_3264_3364 3264 3364 4.757644e+00
R_3364_3464 3364 3464 4.648816e+00
R_3464_3564 3464 3564 2.460154e+00
R_3564_3664 3564 3664 3.171293e+00
R_3664_3764 3664 3764 5.525305e+00
R_3764_3864 3764 3864 5.072705e+00
R_3864_3964 3864 3964 6.978025e-01
R_3964_4064 3964 4064 5.716540e+00
R_4064_4164 4064 4164 8.047884e+00
R_4164_4264 4164 4264 8.561603e-01
R_4264_4364 4264 4364 2.647710e+00
R_4364_4464 4364 4464 9.514722e+00
R_4464_4564 4464 4564 7.829074e+00
R_4564_4664 4564 4664 7.993219e+00
R_4664_4764 4664 4764 5.376624e+00
R_4764_4864 4764 4864 7.674560e+00
R_4864_4964 4864 4964 1.904289e-01
R_4964_5064 4964 5064 7.279226e+00
R_5064_5164 5064 5164 7.098098e+00
R_5164_5264 5164 5264 6.086137e+00
R_5264_5364 5264 5364 2.970020e+00
R_5364_5464 5364 5464 8.258188e+00
R_5464_5564 5464 5564 3.874348e+00
R_5564_5664 5564 5664 4.434765e+00
R_5664_5764 5664 5764 1.538997e+00
R_5764_5864 5764 5864 6.958137e+00
R_5864_5964 5864 5964 6.275114e+00
R_5964_6064 5964 6064 1.641335e+00
R_6064_6164 6064 6164 5.856097e+00
R_6164_6264 6164 6264 5.413864e+00
R_6264_6364 6264 6364 7.927575e+00
R_6364_6464 6364 6464 9.593224e+00
R_6464_6564 6464 6564 9.925217e+00
R_6564_6664 6564 6664 9.650705e+00
R_6664_6764 6664 6764 5.431418e+00
R_6764_6864 6764 6864 7.218328e+00
R_6864_6964 6864 6964 7.477023e+00
R_6964_7064 6964 7064 1.942103e-01
R_7064_7164 7064 7164 3.754696e+00
R_7164_7264 7164 7264 3.550672e+00
R_7264_7364 7264 7364 7.846555e+00
R_7364_7464 7364 7464 7.122664e+00
R_7464_7564 7464 7564 9.809805e-02
R_7564_7664 7564 7664 2.112716e+00
R_7664_7764 7664 7764 5.316581e+00
R_7764_7864 7764 7864 7.610008e+00
R_7864_7964 7864 7964 6.938330e+00
R_7964_8064 7964 8064 2.718906e-02
R_8064_8164 8064 8164 4.029312e+00
R_8164_8264 8164 8264 5.184343e+00
R_8264_8364 8264 8364 2.910925e+00
R_8364_8464 8364 8464 3.061621e+00
R_8464_8564 8464 8564 5.335024e+00
R_8564_8664 8564 8664 9.727114e-01
R_8664_8764 8664 8764 9.019927e+00
R_8764_8864 8764 8864 4.354763e+00
R_8864_8964 8864 8964 4.029988e+00
R_8964_9064 8964 9064 4.279406e+00
R_9064_9164 9064 9164 5.823591e+00
R_9164_9264 9164 9264 5.196422e+00
R_9264_9364 9264 9364 2.293968e+00
R_9364_9464 9364 9464 6.516121e+00
R_9464_9564 9464 9564 8.460394e-01
R_9564_9664 9564 9664 6.938676e+00
R_9664_9764 9664 9764 7.656212e+00
R_9764_9864 9764 9864 3.177626e+00
R_9864_9964 9864 9964 1.024040e+00
R_65_165 65 165 1.633538e+00
R_165_265 165 265 3.265911e+00
R_265_365 265 365 2.184809e+00
R_365_465 365 465 6.893407e+00
R_465_565 465 565 7.663700e+00
R_565_665 565 665 7.701245e-01
R_665_765 665 765 4.358170e+00
R_765_865 765 865 1.403729e+00
R_865_965 865 965 4.693472e-01
R_965_1065 965 1065 8.818295e+00
R_1065_1165 1065 1165 8.696468e+00
R_1165_1265 1165 1265 3.531764e+00
R_1265_1365 1265 1365 9.885447e+00
R_1365_1465 1365 1465 8.436177e-01
R_1465_1565 1465 1565 5.279872e+00
R_1565_1665 1565 1665 7.217521e+00
R_1665_1765 1665 1765 9.116314e+00
R_1765_1865 1765 1865 2.349346e+00
R_1865_1965 1865 1965 3.357287e+00
R_1965_2065 1965 2065 6.123446e+00
R_2065_2165 2065 2165 5.143142e-01
R_2165_2265 2165 2265 9.756699e+00
R_2265_2365 2265 2365 8.305236e+00
R_2365_2465 2365 2465 2.896905e+00
R_2465_2565 2465 2565 4.552299e+00
R_2565_2665 2565 2665 6.221089e+00
R_2665_2765 2665 2765 7.077599e+00
R_2765_2865 2765 2865 3.400072e+00
R_2865_2965 2865 2965 6.011108e+00
R_2965_3065 2965 3065 4.501805e+00
R_3065_3165 3065 3165 9.672804e+00
R_3165_3265 3165 3265 9.357273e+00
R_3265_3365 3265 3365 6.337470e+00
R_3365_3465 3365 3465 7.334712e+00
R_3465_3565 3465 3565 9.525735e+00
R_3565_3665 3565 3665 3.842926e-01
R_3665_3765 3665 3765 5.944861e+00
R_3765_3865 3765 3865 8.893703e+00
R_3865_3965 3865 3965 1.155804e+00
R_3965_4065 3965 4065 1.289748e+00
R_4065_4165 4065 4165 4.124063e+00
R_4165_4265 4165 4265 9.824080e+00
R_4265_4365 4265 4365 6.030089e+00
R_4365_4465 4365 4465 8.003103e+00
R_4465_4565 4465 4565 1.326207e+00
R_4565_4665 4565 4665 1.090436e+00
R_4665_4765 4665 4765 2.512823e+00
R_4765_4865 4765 4865 4.270482e+00
R_4865_4965 4865 4965 8.213576e+00
R_4965_5065 4965 5065 9.953672e+00
R_5065_5165 5065 5165 7.154060e+00
R_5165_5265 5165 5265 6.888035e+00
R_5265_5365 5265 5365 3.372824e+00
R_5365_5465 5365 5465 3.320648e+00
R_5465_5565 5465 5565 5.518417e+00
R_5565_5665 5565 5665 7.964071e+00
R_5665_5765 5665 5765 9.443234e+00
R_5765_5865 5765 5865 6.694375e+00
R_5865_5965 5865 5965 9.066515e+00
R_5965_6065 5965 6065 2.139386e+00
R_6065_6165 6065 6165 4.711497e+00
R_6165_6265 6165 6265 4.451352e+00
R_6265_6365 6265 6365 4.039361e+00
R_6365_6465 6365 6465 3.718969e+00
R_6465_6565 6465 6565 9.487644e+00
R_6565_6665 6565 6665 7.169820e+00
R_6665_6765 6665 6765 1.552261e+00
R_6765_6865 6765 6865 5.265600e+00
R_6865_6965 6865 6965 6.049681e+00
R_6965_7065 6965 7065 6.252074e+00
R_7065_7165 7065 7165 6.189704e+00
R_7165_7265 7165 7265 6.640998e+00
R_7265_7365 7265 7365 9.571201e+00
R_7365_7465 7365 7465 7.647278e+00
R_7465_7565 7465 7565 4.936282e-01
R_7565_7665 7565 7665 8.754561e+00
R_7665_7765 7665 7765 4.175188e+00
R_7765_7865 7765 7865 2.515618e+00
R_7865_7965 7865 7965 9.662623e+00
R_7965_8065 7965 8065 2.708810e+00
R_8065_8165 8065 8165 7.474473e+00
R_8165_8265 8165 8265 5.044748e+00
R_8265_8365 8265 8365 3.469738e+00
R_8365_8465 8365 8465 6.791896e-01
R_8465_8565 8465 8565 9.306432e+00
R_8565_8665 8565 8665 1.298859e+00
R_8665_8765 8665 8765 2.067383e+00
R_8765_8865 8765 8865 2.347242e+00
R_8865_8965 8865 8965 3.601546e+00
R_8965_9065 8965 9065 4.853763e+00
R_9065_9165 9065 9165 5.745733e+00
R_9165_9265 9165 9265 8.025577e+00
R_9265_9365 9265 9365 9.018445e+00
R_9365_9465 9365 9465 7.119458e+00
R_9465_9565 9465 9565 5.712156e-01
R_9565_9665 9565 9665 1.349724e+00
R_9665_9765 9665 9765 4.979877e+00
R_9765_9865 9765 9865 4.983683e+00
R_9865_9965 9865 9965 4.955188e+00
R_66_166 66 166 5.701487e+00
R_166_266 166 266 5.081208e+00
R_266_366 266 366 9.512802e+00
R_366_466 366 466 2.480158e+00
R_466_566 466 566 5.007852e+00
R_566_666 566 666 3.896635e+00
R_666_766 666 766 8.738635e+00
R_766_866 766 866 6.484842e-01
R_866_966 866 966 8.440405e+00
R_966_1066 966 1066 6.537484e+00
R_1066_1166 1066 1166 2.098344e+00
R_1166_1266 1166 1266 1.389131e+00
R_1266_1366 1266 1366 7.919430e+00
R_1366_1466 1366 1466 1.978583e+00
R_1466_1566 1466 1566 8.217558e-01
R_1566_1666 1566 1666 1.157688e+00
R_1666_1766 1666 1766 8.436053e+00
R_1766_1866 1766 1866 8.118410e+00
R_1866_1966 1866 1966 2.028673e+00
R_1966_2066 1966 2066 5.649051e+00
R_2066_2166 2066 2166 4.090743e+00
R_2166_2266 2166 2266 1.952872e+00
R_2266_2366 2266 2366 9.190681e+00
R_2366_2466 2366 2466 7.994979e+00
R_2466_2566 2466 2566 8.928072e+00
R_2566_2666 2566 2666 1.089345e+00
R_2666_2766 2666 2766 9.723705e+00
R_2766_2866 2766 2866 2.271051e-01
R_2866_2966 2866 2966 8.562908e+00
R_2966_3066 2966 3066 2.550283e+00
R_3066_3166 3066 3166 7.907528e+00
R_3166_3266 3166 3266 3.832808e+00
R_3266_3366 3266 3366 2.428616e+00
R_3366_3466 3366 3466 1.551676e+00
R_3466_3566 3466 3566 5.910987e+00
R_3566_3666 3566 3666 5.177415e+00
R_3666_3766 3666 3766 2.580408e+00
R_3766_3866 3766 3866 5.030590e+00
R_3866_3966 3866 3966 4.030337e+00
R_3966_4066 3966 4066 8.855586e+00
R_4066_4166 4066 4166 6.712154e+00
R_4166_4266 4166 4266 3.945306e-01
R_4266_4366 4266 4366 1.838729e+00
R_4366_4466 4366 4466 8.884368e+00
R_4466_4566 4466 4566 9.799749e+00
R_4566_4666 4566 4666 7.265331e+00
R_4666_4766 4666 4766 4.665709e+00
R_4766_4866 4766 4866 1.723769e+00
R_4866_4966 4866 4966 8.294916e+00
R_4966_5066 4966 5066 1.848789e+00
R_5066_5166 5066 5166 4.141860e+00
R_5166_5266 5166 5266 9.227506e+00
R_5266_5366 5266 5366 1.717408e+00
R_5366_5466 5366 5466 3.827347e+00
R_5466_5566 5466 5566 8.358745e+00
R_5566_5666 5566 5666 3.425789e+00
R_5666_5766 5666 5766 7.233876e+00
R_5766_5866 5766 5866 6.618367e+00
R_5866_5966 5866 5966 4.797036e+00
R_5966_6066 5966 6066 8.898374e+00
R_6066_6166 6066 6166 7.750568e+00
R_6166_6266 6166 6266 3.904143e+00
R_6266_6366 6266 6366 2.813264e+00
R_6366_6466 6366 6466 7.282753e+00
R_6466_6566 6466 6566 2.190648e+00
R_6566_6666 6566 6666 2.557342e+00
R_6666_6766 6666 6766 5.206293e+00
R_6766_6866 6766 6866 7.305716e+00
R_6866_6966 6866 6966 9.699188e+00
R_6966_7066 6966 7066 6.560608e+00
R_7066_7166 7066 7166 2.752776e+00
R_7166_7266 7166 7266 1.435753e+00
R_7266_7366 7266 7366 7.934764e+00
R_7366_7466 7366 7466 9.401667e+00
R_7466_7566 7466 7566 7.820599e+00
R_7566_7666 7566 7666 9.203413e+00
R_7666_7766 7666 7766 2.309214e-01
R_7766_7866 7766 7866 6.343922e-01
R_7866_7966 7866 7966 3.681371e+00
R_7966_8066 7966 8066 7.407797e+00
R_8066_8166 8066 8166 5.321710e+00
R_8166_8266 8166 8266 7.536882e-02
R_8266_8366 8266 8366 3.202088e+00
R_8366_8466 8366 8466 2.126600e+00
R_8466_8566 8466 8566 7.112766e+00
R_8566_8666 8566 8666 4.109723e+00
R_8666_8766 8666 8766 9.598376e+00
R_8766_8866 8766 8866 2.634598e+00
R_8866_8966 8866 8966 6.238593e+00
R_8966_9066 8966 9066 5.934111e+00
R_9066_9166 9066 9166 6.313716e-01
R_9166_9266 9166 9266 1.470480e+00
R_9266_9366 9266 9366 9.667969e+00
R_9366_9466 9366 9466 3.443319e+00
R_9466_9566 9466 9566 7.927346e+00
R_9566_9666 9566 9666 9.039634e+00
R_9666_9766 9666 9766 7.698311e+00
R_9766_9866 9766 9866 1.318552e+00
R_9866_9966 9866 9966 1.841520e+00
R_67_167 67 167 9.326263e+00
R_167_267 167 267 3.464243e+00
R_267_367 267 367 4.721475e+00
R_367_467 367 467 7.835560e+00
R_467_567 467 567 9.780366e+00
R_567_667 567 667 1.767860e+00
R_667_767 667 767 1.491267e+00
R_767_867 767 867 5.887771e+00
R_867_967 867 967 6.445234e+00
R_967_1067 967 1067 2.931518e+00
R_1067_1167 1067 1167 1.926531e+00
R_1167_1267 1167 1267 7.934115e+00
R_1267_1367 1267 1367 5.414897e+00
R_1367_1467 1367 1467 2.861636e+00
R_1467_1567 1467 1567 8.047132e+00
R_1567_1667 1567 1667 4.112687e+00
R_1667_1767 1667 1767 6.144521e+00
R_1767_1867 1767 1867 3.462077e+00
R_1867_1967 1867 1967 9.074041e+00
R_1967_2067 1967 2067 3.144333e+00
R_2067_2167 2067 2167 6.204737e+00
R_2167_2267 2167 2267 3.487190e+00
R_2267_2367 2267 2367 5.389784e+00
R_2367_2467 2367 2467 9.002234e+00
R_2467_2567 2467 2567 3.263388e+00
R_2567_2667 2567 2667 2.903347e+00
R_2667_2767 2667 2767 9.383549e-01
R_2767_2867 2767 2867 2.827163e+00
R_2867_2967 2867 2967 7.830951e-01
R_2967_3067 2967 3067 6.928678e+00
R_3067_3167 3067 3167 1.808653e+00
R_3167_3267 3167 3267 3.775239e+00
R_3267_3367 3267 3367 5.353835e+00
R_3367_3467 3367 3467 1.446250e+00
R_3467_3567 3467 3567 9.953099e+00
R_3567_3667 3567 3667 3.900650e-01
R_3667_3767 3667 3767 1.184411e+00
R_3767_3867 3767 3867 8.724903e+00
R_3867_3967 3867 3967 6.707605e+00
R_3967_4067 3967 4067 9.165504e+00
R_4067_4167 4067 4167 4.737573e+00
R_4167_4267 4167 4267 9.642868e+00
R_4267_4367 4267 4367 4.394443e+00
R_4367_4467 4367 4467 6.529253e+00
R_4467_4567 4467 4567 3.225874e+00
R_4567_4667 4567 4667 5.113589e+00
R_4667_4767 4667 4767 5.584449e+00
R_4767_4867 4767 4867 1.017605e+00
R_4867_4967 4867 4967 4.672473e+00
R_4967_5067 4967 5067 7.741921e+00
R_5067_5167 5067 5167 3.776270e+00
R_5167_5267 5167 5267 6.779680e+00
R_5267_5367 5267 5367 1.645218e+00
R_5367_5467 5367 5467 8.268474e+00
R_5467_5567 5467 5567 8.906888e+00
R_5567_5667 5567 5667 1.663273e+00
R_5667_5767 5667 5767 2.761093e+00
R_5767_5867 5767 5867 2.357509e+00
R_5867_5967 5867 5967 4.470464e+00
R_5967_6067 5967 6067 2.687465e+00
R_6067_6167 6067 6167 8.837436e+00
R_6167_6267 6167 6267 3.976098e+00
R_6267_6367 6267 6367 9.261522e+00
R_6367_6467 6367 6467 2.736838e-01
R_6467_6567 6467 6567 6.916004e+00
R_6567_6667 6567 6667 5.352306e+00
R_6667_6767 6667 6767 1.904150e+00
R_6767_6867 6767 6867 1.372033e+00
R_6867_6967 6867 6967 3.112759e-01
R_6967_7067 6967 7067 5.404470e+00
R_7067_7167 7067 7167 4.154862e+00
R_7167_7267 7167 7267 3.121226e+00
R_7267_7367 7267 7367 1.864315e+00
R_7367_7467 7367 7467 3.197626e+00
R_7467_7567 7467 7567 1.110858e+00
R_7567_7667 7567 7667 1.866762e+00
R_7667_7767 7667 7767 4.330949e+00
R_7767_7867 7767 7867 9.802677e+00
R_7867_7967 7867 7967 4.950689e+00
R_7967_8067 7967 8067 6.461708e+00
R_8067_8167 8067 8167 8.397995e+00
R_8167_8267 8167 8267 2.751701e+00
R_8267_8367 8267 8367 5.403851e+00
R_8367_8467 8367 8467 2.939015e+00
R_8467_8567 8467 8567 6.107633e+00
R_8567_8667 8567 8667 4.584193e+00
R_8667_8767 8667 8767 5.664522e+00
R_8767_8867 8767 8867 1.612711e+00
R_8867_8967 8867 8967 5.338422e+00
R_8967_9067 8967 9067 7.877117e+00
R_9067_9167 9067 9167 9.844935e+00
R_9167_9267 9167 9267 2.928522e+00
R_9267_9367 9267 9367 2.628005e+00
R_9367_9467 9367 9467 5.580315e+00
R_9467_9567 9467 9567 5.375874e+00
R_9567_9667 9567 9667 7.901026e+00
R_9667_9767 9667 9767 6.320559e+00
R_9767_9867 9767 9867 8.859828e+00
R_9867_9967 9867 9967 5.350036e+00
R_68_168 68 168 7.495431e+00
R_168_268 168 268 9.823080e+00
R_268_368 268 368 3.052784e+00
R_368_468 368 468 3.546670e+00
R_468_568 468 568 2.106703e+00
R_568_668 568 668 9.541833e+00
R_668_768 668 768 4.054551e+00
R_768_868 768 868 2.375774e+00
R_868_968 868 968 8.417380e+00
R_968_1068 968 1068 5.780676e+00
R_1068_1168 1068 1168 7.915324e+00
R_1168_1268 1168 1268 4.019062e+00
R_1268_1368 1268 1368 2.541228e-01
R_1368_1468 1368 1468 7.494793e+00
R_1468_1568 1468 1568 7.161247e+00
R_1568_1668 1568 1668 8.948131e+00
R_1668_1768 1668 1768 5.883630e+00
R_1768_1868 1768 1868 3.196352e+00
R_1868_1968 1868 1968 6.572080e+00
R_1968_2068 1968 2068 3.107894e+00
R_2068_2168 2068 2168 2.423652e+00
R_2168_2268 2168 2268 7.129015e+00
R_2268_2368 2268 2368 8.976010e+00
R_2368_2468 2368 2468 1.908860e+00
R_2468_2568 2468 2568 9.481213e+00
R_2568_2668 2568 2668 5.031855e+00
R_2668_2768 2668 2768 1.138938e+00
R_2768_2868 2768 2868 7.001002e+00
R_2868_2968 2868 2968 5.765549e+00
R_2968_3068 2968 3068 4.757823e+00
R_3068_3168 3068 3168 2.233467e+00
R_3168_3268 3168 3268 6.025092e+00
R_3268_3368 3268 3368 7.513495e+00
R_3368_3468 3368 3468 8.321125e+00
R_3468_3568 3468 3568 2.046322e+00
R_3568_3668 3568 3668 9.728369e+00
R_3668_3768 3668 3768 3.925354e+00
R_3768_3868 3768 3868 7.881831e+00
R_3868_3968 3868 3968 6.891972e-01
R_3968_4068 3968 4068 9.303015e+00
R_4068_4168 4068 4168 2.975581e+00
R_4168_4268 4168 4268 3.255450e+00
R_4268_4368 4268 4368 2.595508e+00
R_4368_4468 4368 4468 7.705347e+00
R_4468_4568 4468 4568 3.604683e+00
R_4568_4668 4568 4668 9.282711e+00
R_4668_4768 4668 4768 6.021772e+00
R_4768_4868 4768 4868 9.734630e+00
R_4868_4968 4868 4968 4.636736e+00
R_4968_5068 4968 5068 2.500778e+00
R_5068_5168 5068 5168 3.370314e+00
R_5168_5268 5168 5268 6.244692e+00
R_5268_5368 5268 5368 9.317892e+00
R_5368_5468 5368 5468 6.499411e+00
R_5468_5568 5468 5568 7.887110e+00
R_5568_5668 5568 5668 1.461064e+00
R_5668_5768 5668 5768 4.458713e+00
R_5768_5868 5768 5868 3.202159e+00
R_5868_5968 5868 5968 7.938794e-03
R_5968_6068 5968 6068 3.053463e+00
R_6068_6168 6068 6168 5.120864e+00
R_6168_6268 6168 6268 8.507281e+00
R_6268_6368 6268 6368 5.276119e+00
R_6368_6468 6368 6468 2.794940e+00
R_6468_6568 6468 6568 5.848534e+00
R_6568_6668 6568 6668 4.341124e+00
R_6668_6768 6668 6768 5.670724e+00
R_6768_6868 6768 6868 6.076393e+00
R_6868_6968 6868 6968 6.076724e-01
R_6968_7068 6968 7068 2.502983e+00
R_7068_7168 7068 7168 8.973685e+00
R_7168_7268 7168 7268 3.048176e+00
R_7268_7368 7268 7368 4.994416e+00
R_7368_7468 7368 7468 1.850434e+00
R_7468_7568 7468 7568 2.051262e+00
R_7568_7668 7568 7668 8.175423e+00
R_7668_7768 7668 7768 3.064858e+00
R_7768_7868 7768 7868 9.794593e-01
R_7868_7968 7868 7968 3.682955e+00
R_7968_8068 7968 8068 2.442715e+00
R_8068_8168 8068 8168 8.677855e+00
R_8168_8268 8168 8268 2.219735e+00
R_8268_8368 8268 8368 8.141456e+00
R_8368_8468 8368 8468 9.516980e+00
R_8468_8568 8468 8568 4.119488e+00
R_8568_8668 8568 8668 8.322536e+00
R_8668_8768 8668 8768 1.415327e+00
R_8768_8868 8768 8868 2.193591e+00
R_8868_8968 8868 8968 5.488386e+00
R_8968_9068 8968 9068 2.970664e+00
R_9068_9168 9068 9168 1.526062e+00
R_9168_9268 9168 9268 7.050775e+00
R_9268_9368 9268 9368 7.646395e+00
R_9368_9468 9368 9468 3.113195e+00
R_9468_9568 9468 9568 6.890686e+00
R_9568_9668 9568 9668 5.457307e+00
R_9668_9768 9668 9768 5.676179e+00
R_9768_9868 9768 9868 8.357320e+00
R_9868_9968 9868 9968 5.723231e+00
R_69_169 69 169 1.879060e+00
R_169_269 169 269 1.454936e+00
R_269_369 269 369 4.309043e+00
R_369_469 369 469 1.822492e+00
R_469_569 469 569 2.922276e+00
R_569_669 569 669 2.924439e+00
R_669_769 669 769 5.176600e+00
R_769_869 769 869 6.906496e+00
R_869_969 869 969 7.531415e-01
R_969_1069 969 1069 7.268946e+00
R_1069_1169 1069 1169 2.394272e+00
R_1169_1269 1169 1269 1.957845e+00
R_1269_1369 1269 1369 4.700971e+00
R_1369_1469 1369 1469 8.186536e+00
R_1469_1569 1469 1569 9.527002e+00
R_1569_1669 1569 1669 2.595257e+00
R_1669_1769 1669 1769 3.615322e+00
R_1769_1869 1769 1869 4.236373e+00
R_1869_1969 1869 1969 4.419251e+00
R_1969_2069 1969 2069 1.547840e+00
R_2069_2169 2069 2169 5.208332e+00
R_2169_2269 2169 2269 6.878279e+00
R_2269_2369 2269 2369 8.015377e+00
R_2369_2469 2369 2469 3.237802e+00
R_2469_2569 2469 2569 6.941132e+00
R_2569_2669 2569 2669 8.636569e+00
R_2669_2769 2669 2769 8.402869e+00
R_2769_2869 2769 2869 7.766767e+00
R_2869_2969 2869 2969 5.900205e+00
R_2969_3069 2969 3069 8.357615e+00
R_3069_3169 3069 3169 4.140423e+00
R_3169_3269 3169 3269 3.255170e-01
R_3269_3369 3269 3369 7.922462e+00
R_3369_3469 3369 3469 4.639915e+00
R_3469_3569 3469 3569 3.628661e+00
R_3569_3669 3569 3669 4.322976e+00
R_3669_3769 3669 3769 4.583362e+00
R_3769_3869 3769 3869 6.312527e+00
R_3869_3969 3869 3969 9.851809e+00
R_3969_4069 3969 4069 9.059471e+00
R_4069_4169 4069 4169 8.347805e+00
R_4169_4269 4169 4269 5.931079e+00
R_4269_4369 4269 4369 8.638584e+00
R_4369_4469 4369 4469 1.434801e+00
R_4469_4569 4469 4569 2.081717e+00
R_4569_4669 4569 4669 9.510191e+00
R_4669_4769 4669 4769 5.791870e+00
R_4769_4869 4769 4869 8.233150e-01
R_4869_4969 4869 4969 3.931105e+00
R_4969_5069 4969 5069 8.743079e+00
R_5069_5169 5069 5169 8.726605e+00
R_5169_5269 5169 5269 6.856227e+00
R_5269_5369 5269 5369 7.772976e+00
R_5369_5469 5369 5469 2.716515e+00
R_5469_5569 5469 5569 1.943549e+00
R_5569_5669 5569 5669 7.459833e+00
R_5669_5769 5669 5769 8.038435e+00
R_5769_5869 5769 5869 3.299417e+00
R_5869_5969 5869 5969 4.749283e-01
R_5969_6069 5969 6069 7.024393e+00
R_6069_6169 6069 6169 8.047182e+00
R_6169_6269 6169 6269 3.922404e+00
R_6269_6369 6269 6369 5.050165e+00
R_6369_6469 6369 6469 8.591950e+00
R_6469_6569 6469 6569 7.008584e+00
R_6569_6669 6569 6669 3.057798e+00
R_6669_6769 6669 6769 7.644788e+00
R_6769_6869 6769 6869 3.344224e+00
R_6869_6969 6869 6969 1.025129e-01
R_6969_7069 6969 7069 1.620272e+00
R_7069_7169 7069 7169 3.834410e+00
R_7169_7269 7169 7269 5.504426e-01
R_7269_7369 7269 7369 7.670127e-01
R_7369_7469 7369 7469 1.050286e+00
R_7469_7569 7469 7569 8.540330e+00
R_7569_7669 7569 7669 5.477768e+00
R_7669_7769 7669 7769 3.333858e+00
R_7769_7869 7769 7869 7.333112e+00
R_7869_7969 7869 7969 2.048157e+00
R_7969_8069 7969 8069 1.990901e+00
R_8069_8169 8069 8169 9.391642e+00
R_8169_8269 8169 8269 5.332546e+00
R_8269_8369 8269 8369 6.416466e+00
R_8369_8469 8369 8469 6.067010e+00
R_8469_8569 8469 8569 9.921184e-01
R_8569_8669 8569 8669 8.070458e+00
R_8669_8769 8669 8769 2.411270e+00
R_8769_8869 8769 8869 7.293584e+00
R_8869_8969 8869 8969 7.064494e+00
R_8969_9069 8969 9069 7.094913e+00
R_9069_9169 9069 9169 1.304716e+00
R_9169_9269 9169 9269 1.676516e+00
R_9269_9369 9269 9369 4.404142e+00
R_9369_9469 9369 9469 6.984226e+00
R_9469_9569 9469 9569 8.920277e+00
R_9569_9669 9569 9669 7.056479e+00
R_9669_9769 9669 9769 5.750451e+00
R_9769_9869 9769 9869 3.033213e+00
R_9869_9969 9869 9969 8.910346e+00
R_70_170 70 170 2.211218e+00
R_170_270 170 270 5.698069e+00
R_270_370 270 370 5.225393e+00
R_370_470 370 470 6.218655e+00
R_470_570 470 570 6.837870e+00
R_570_670 570 670 1.069935e+00
R_670_770 670 770 7.042909e+00
R_770_870 770 870 1.096170e+00
R_870_970 870 970 8.516420e+00
R_970_1070 970 1070 3.822005e+00
R_1070_1170 1070 1170 7.555916e+00
R_1170_1270 1170 1270 5.119919e+00
R_1270_1370 1270 1370 4.677520e-01
R_1370_1470 1370 1470 6.958827e+00
R_1470_1570 1470 1570 4.800864e+00
R_1570_1670 1570 1670 2.127475e-01
R_1670_1770 1670 1770 6.160406e+00
R_1770_1870 1770 1870 1.746580e+00
R_1870_1970 1870 1970 8.165543e+00
R_1970_2070 1970 2070 6.060449e+00
R_2070_2170 2070 2170 9.549033e+00
R_2170_2270 2170 2270 3.448462e+00
R_2270_2370 2270 2370 2.314736e+00
R_2370_2470 2370 2470 2.665481e+00
R_2470_2570 2470 2570 6.218526e+00
R_2570_2670 2570 2670 2.301718e+00
R_2670_2770 2670 2770 6.146975e+00
R_2770_2870 2770 2870 8.286941e+00
R_2870_2970 2870 2970 6.096857e+00
R_2970_3070 2970 3070 7.290964e-01
R_3070_3170 3070 3170 7.206215e+00
R_3170_3270 3170 3270 2.201212e+00
R_3270_3370 3270 3370 1.375022e+00
R_3370_3470 3370 3470 3.611839e+00
R_3470_3570 3470 3570 6.827964e+00
R_3570_3670 3570 3670 4.228091e+00
R_3670_3770 3670 3770 2.594498e+00
R_3770_3870 3770 3870 7.589176e+00
R_3870_3970 3870 3970 6.476551e+00
R_3970_4070 3970 4070 2.994735e+00
R_4070_4170 4070 4170 2.446392e+00
R_4170_4270 4170 4270 5.242350e+00
R_4270_4370 4270 4370 2.712020e+00
R_4370_4470 4370 4470 7.685764e+00
R_4470_4570 4470 4570 3.613504e+00
R_4570_4670 4570 4670 9.471971e+00
R_4670_4770 4670 4770 7.576126e+00
R_4770_4870 4770 4870 3.983274e+00
R_4870_4970 4870 4970 7.534217e+00
R_4970_5070 4970 5070 3.226932e+00
R_5070_5170 5070 5170 2.836386e+00
R_5170_5270 5170 5270 9.960426e+00
R_5270_5370 5270 5370 6.582224e+00
R_5370_5470 5370 5470 3.090934e+00
R_5470_5570 5470 5570 3.455039e+00
R_5570_5670 5570 5670 5.689967e+00
R_5670_5770 5670 5770 5.221148e+00
R_5770_5870 5770 5870 8.006601e-01
R_5870_5970 5870 5970 7.670428e-01
R_5970_6070 5970 6070 6.176814e+00
R_6070_6170 6070 6170 5.760440e+00
R_6170_6270 6170 6270 5.516629e+00
R_6270_6370 6270 6370 4.958485e+00
R_6370_6470 6370 6470 4.693830e+00
R_6470_6570 6470 6570 2.680549e+00
R_6570_6670 6570 6670 3.013802e+00
R_6670_6770 6670 6770 4.519981e+00
R_6770_6870 6770 6870 9.552122e+00
R_6870_6970 6870 6970 9.308984e+00
R_6970_7070 6970 7070 3.019713e+00
R_7070_7170 7070 7170 7.217864e+00
R_7170_7270 7170 7270 9.648133e+00
R_7270_7370 7270 7370 5.822830e+00
R_7370_7470 7370 7470 9.097012e+00
R_7470_7570 7470 7570 9.040784e+00
R_7570_7670 7570 7670 2.931588e+00
R_7670_7770 7670 7770 9.479975e+00
R_7770_7870 7770 7870 7.502442e+00
R_7870_7970 7870 7970 4.967576e+00
R_7970_8070 7970 8070 6.356705e+00
R_8070_8170 8070 8170 2.239009e+00
R_8170_8270 8170 8270 4.361458e+00
R_8270_8370 8270 8370 6.801287e+00
R_8370_8470 8370 8470 4.381127e-01
R_8470_8570 8470 8570 8.172937e+00
R_8570_8670 8570 8670 1.399034e+00
R_8670_8770 8670 8770 8.194079e+00
R_8770_8870 8770 8870 4.373343e+00
R_8870_8970 8870 8970 1.426562e+00
R_8970_9070 8970 9070 8.154220e+00
R_9070_9170 9070 9170 8.811586e+00
R_9170_9270 9170 9270 1.105021e-01
R_9270_9370 9270 9370 3.845430e+00
R_9370_9470 9370 9470 3.030996e+00
R_9470_9570 9470 9570 4.271748e+00
R_9570_9670 9570 9670 9.430309e+00
R_9670_9770 9670 9770 9.841350e+00
R_9770_9870 9770 9870 3.118271e+00
R_9870_9970 9870 9970 5.347367e+00
R_71_171 71 171 2.608560e+00
R_171_271 171 271 7.882435e+00
R_271_371 271 371 2.445633e+00
R_371_471 371 471 4.636429e+00
R_471_571 471 571 9.527913e+00
R_571_671 571 671 2.592080e+00
R_671_771 671 771 3.893253e-01
R_771_871 771 871 2.696427e+00
R_871_971 871 971 1.194846e-01
R_971_1071 971 1071 8.586180e-01
R_1071_1171 1071 1171 3.135316e+00
R_1171_1271 1171 1271 2.179002e+00
R_1271_1371 1271 1371 7.493877e+00
R_1371_1471 1371 1471 6.308647e-01
R_1471_1571 1471 1571 4.295515e+00
R_1571_1671 1571 1671 4.477964e+00
R_1671_1771 1671 1771 5.886225e+00
R_1771_1871 1771 1871 8.243230e+00
R_1871_1971 1871 1971 2.725201e+00
R_1971_2071 1971 2071 3.441299e+00
R_2071_2171 2071 2171 4.040830e+00
R_2171_2271 2171 2271 1.128139e+00
R_2271_2371 2271 2371 4.106443e+00
R_2371_2471 2371 2471 9.332244e+00
R_2471_2571 2471 2571 7.154464e+00
R_2571_2671 2571 2671 4.102543e+00
R_2671_2771 2671 2771 8.874369e+00
R_2771_2871 2771 2871 1.182421e+00
R_2871_2971 2871 2971 7.978674e-01
R_2971_3071 2971 3071 9.581114e+00
R_3071_3171 3071 3171 1.035886e+00
R_3171_3271 3171 3271 3.394798e+00
R_3271_3371 3271 3371 3.655514e+00
R_3371_3471 3371 3471 8.121624e+00
R_3471_3571 3471 3571 9.406615e+00
R_3571_3671 3571 3671 2.245470e-01
R_3671_3771 3671 3771 3.187574e+00
R_3771_3871 3771 3871 9.610715e+00
R_3871_3971 3871 3971 1.144388e+00
R_3971_4071 3971 4071 3.318302e+00
R_4071_4171 4071 4171 2.713526e+00
R_4171_4271 4171 4271 7.838779e+00
R_4271_4371 4271 4371 6.279020e+00
R_4371_4471 4371 4471 2.172867e+00
R_4471_4571 4471 4571 2.765341e+00
R_4571_4671 4571 4671 2.347478e+00
R_4671_4771 4671 4771 8.225348e+00
R_4771_4871 4771 4871 3.228112e+00
R_4871_4971 4871 4971 6.676738e+00
R_4971_5071 4971 5071 2.386555e-01
R_5071_5171 5071 5171 6.343240e+00
R_5171_5271 5171 5271 7.346537e+00
R_5271_5371 5271 5371 8.723255e+00
R_5371_5471 5371 5471 3.694865e+00
R_5471_5571 5471 5571 8.242712e+00
R_5571_5671 5571 5671 2.775393e+00
R_5671_5771 5671 5771 7.330551e+00
R_5771_5871 5771 5871 7.585430e+00
R_5871_5971 5871 5971 1.624788e-01
R_5971_6071 5971 6071 7.797493e+00
R_6071_6171 6071 6171 6.430136e+00
R_6171_6271 6171 6271 1.787224e+00
R_6271_6371 6271 6371 6.642899e-02
R_6371_6471 6371 6471 4.320054e+00
R_6471_6571 6471 6571 4.516339e-01
R_6571_6671 6571 6671 8.822288e+00
R_6671_6771 6671 6771 1.315056e+00
R_6771_6871 6771 6871 7.932569e+00
R_6871_6971 6871 6971 4.603740e+00
R_6971_7071 6971 7071 1.189696e+00
R_7071_7171 7071 7171 9.875597e+00
R_7171_7271 7171 7271 6.123883e+00
R_7271_7371 7271 7371 5.547204e+00
R_7371_7471 7371 7471 7.684220e+00
R_7471_7571 7471 7571 7.188247e+00
R_7571_7671 7571 7671 4.113951e+00
R_7671_7771 7671 7771 2.109792e-01
R_7771_7871 7771 7871 3.022193e+00
R_7871_7971 7871 7971 4.843984e+00
R_7971_8071 7971 8071 6.850293e+00
R_8071_8171 8071 8171 2.888385e+00
R_8171_8271 8171 8271 6.546002e+00
R_8271_8371 8271 8371 8.164536e+00
R_8371_8471 8371 8471 1.367253e+00
R_8471_8571 8471 8571 3.694339e+00
R_8571_8671 8571 8671 4.059654e+00
R_8671_8771 8671 8771 2.304506e+00
R_8771_8871 8771 8871 9.221511e+00
R_8871_8971 8871 8971 3.810922e+00
R_8971_9071 8971 9071 7.445537e+00
R_9071_9171 9071 9171 7.001337e+00
R_9171_9271 9171 9271 6.705642e+00
R_9271_9371 9271 9371 1.524222e+00
R_9371_9471 9371 9471 5.435941e+00
R_9471_9571 9471 9571 2.090625e+00
R_9571_9671 9571 9671 8.849527e-01
R_9671_9771 9671 9771 8.290095e-02
R_9771_9871 9771 9871 6.632335e+00
R_9871_9971 9871 9971 8.162015e+00
R_72_172 72 172 6.956906e-01
R_172_272 172 272 6.137896e+00
R_272_372 272 372 9.728393e+00
R_372_472 372 472 8.220647e+00
R_472_572 472 572 8.173485e+00
R_572_672 572 672 9.662424e+00
R_672_772 672 772 2.599371e+00
R_772_872 772 872 1.731172e+00
R_872_972 872 972 1.769403e+00
R_972_1072 972 1072 8.373565e+00
R_1072_1172 1072 1172 2.001579e+00
R_1172_1272 1172 1272 5.286815e+00
R_1272_1372 1272 1372 9.104644e+00
R_1372_1472 1372 1472 1.514190e+00
R_1472_1572 1472 1572 9.275963e+00
R_1572_1672 1572 1672 9.985512e+00
R_1672_1772 1672 1772 3.885512e+00
R_1772_1872 1772 1872 5.334412e+00
R_1872_1972 1872 1972 6.546296e+00
R_1972_2072 1972 2072 9.718785e+00
R_2072_2172 2072 2172 5.477475e+00
R_2172_2272 2172 2272 7.654077e+00
R_2272_2372 2272 2372 9.925974e+00
R_2372_2472 2372 2472 2.365409e+00
R_2472_2572 2472 2572 8.062335e+00
R_2572_2672 2572 2672 4.643335e-01
R_2672_2772 2672 2772 9.866553e+00
R_2772_2872 2772 2872 4.154154e+00
R_2872_2972 2872 2972 6.285872e+00
R_2972_3072 2972 3072 8.500675e+00
R_3072_3172 3072 3172 8.687678e+00
R_3172_3272 3172 3272 1.178705e+00
R_3272_3372 3272 3372 2.576912e+00
R_3372_3472 3372 3472 9.017903e+00
R_3472_3572 3472 3572 5.758395e+00
R_3572_3672 3572 3672 3.415251e+00
R_3672_3772 3672 3772 1.105474e-01
R_3772_3872 3772 3872 4.460760e+00
R_3872_3972 3872 3972 9.599533e-01
R_3972_4072 3972 4072 9.003690e+00
R_4072_4172 4072 4172 1.765403e-01
R_4172_4272 4172 4272 8.513437e+00
R_4272_4372 4272 4372 7.447998e+00
R_4372_4472 4372 4472 2.523873e+00
R_4472_4572 4472 4572 8.600002e+00
R_4572_4672 4572 4672 1.515021e+00
R_4672_4772 4672 4772 4.694950e+00
R_4772_4872 4772 4872 4.273038e+00
R_4872_4972 4872 4972 2.330365e+00
R_4972_5072 4972 5072 3.064643e+00
R_5072_5172 5072 5172 6.126517e+00
R_5172_5272 5172 5272 7.095331e+00
R_5272_5372 5272 5372 3.366707e+00
R_5372_5472 5372 5472 6.351126e+00
R_5472_5572 5472 5572 2.912159e-01
R_5572_5672 5572 5672 1.252551e+00
R_5672_5772 5672 5772 9.314008e+00
R_5772_5872 5772 5872 8.016698e-01
R_5872_5972 5872 5972 7.918952e+00
R_5972_6072 5972 6072 3.341669e+00
R_6072_6172 6072 6172 8.678297e+00
R_6172_6272 6172 6272 5.500592e+00
R_6272_6372 6272 6372 7.505046e-01
R_6372_6472 6372 6472 6.176552e-01
R_6472_6572 6472 6572 3.733299e+00
R_6572_6672 6572 6672 1.343296e+00
R_6672_6772 6672 6772 3.765530e+00
R_6772_6872 6772 6872 5.686324e+00
R_6872_6972 6872 6972 7.454204e+00
R_6972_7072 6972 7072 3.085600e+00
R_7072_7172 7072 7172 4.703633e-01
R_7172_7272 7172 7272 4.050852e+00
R_7272_7372 7272 7372 1.289072e-02
R_7372_7472 7372 7472 3.125464e+00
R_7472_7572 7472 7572 2.809826e+00
R_7572_7672 7572 7672 9.606127e+00
R_7672_7772 7672 7772 5.321787e+00
R_7772_7872 7772 7872 7.794772e+00
R_7872_7972 7872 7972 9.621183e+00
R_7972_8072 7972 8072 2.507671e+00
R_8072_8172 8072 8172 8.944569e+00
R_8172_8272 8172 8272 8.302127e+00
R_8272_8372 8272 8372 6.849583e+00
R_8372_8472 8372 8472 8.125480e+00
R_8472_8572 8472 8572 2.986210e+00
R_8572_8672 8572 8672 9.912216e+00
R_8672_8772 8672 8772 6.804696e+00
R_8772_8872 8772 8872 8.741900e+00
R_8872_8972 8872 8972 4.552955e+00
R_8972_9072 8972 9072 1.463198e+00
R_9072_9172 9072 9172 9.455724e+00
R_9172_9272 9172 9272 6.932350e+00
R_9272_9372 9272 9372 4.710155e+00
R_9372_9472 9372 9472 9.278958e-01
R_9472_9572 9472 9572 4.108760e+00
R_9572_9672 9572 9672 1.999894e+00
R_9672_9772 9672 9772 8.196442e+00
R_9772_9872 9772 9872 6.943588e+00
R_9872_9972 9872 9972 7.090031e+00
R_73_173 73 173 4.326583e+00
R_173_273 173 273 7.725036e+00
R_273_373 273 373 9.249979e+00
R_373_473 373 473 8.257414e+00
R_473_573 473 573 4.097144e+00
R_573_673 573 673 4.043721e+00
R_673_773 673 773 2.459372e-01
R_773_873 773 873 9.150797e+00
R_873_973 873 973 8.028785e+00
R_973_1073 973 1073 9.575601e+00
R_1073_1173 1073 1173 6.518921e+00
R_1173_1273 1173 1273 2.337532e-01
R_1273_1373 1273 1373 7.627024e+00
R_1373_1473 1373 1473 6.021102e+00
R_1473_1573 1473 1573 6.475715e+00
R_1573_1673 1573 1673 4.955045e+00
R_1673_1773 1673 1773 2.477757e+00
R_1773_1873 1773 1873 1.494214e+00
R_1873_1973 1873 1973 5.020855e-02
R_1973_2073 1973 2073 1.556351e+00
R_2073_2173 2073 2173 2.881627e+00
R_2173_2273 2173 2273 1.721772e+00
R_2273_2373 2273 2373 7.875786e+00
R_2373_2473 2373 2473 2.498802e+00
R_2473_2573 2473 2573 4.768126e+00
R_2573_2673 2573 2673 8.959446e+00
R_2673_2773 2673 2773 1.594933e+00
R_2773_2873 2773 2873 4.864878e+00
R_2873_2973 2873 2973 5.870129e+00
R_2973_3073 2973 3073 5.902899e+00
R_3073_3173 3073 3173 2.582192e+00
R_3173_3273 3173 3273 3.998882e+00
R_3273_3373 3273 3373 7.471562e+00
R_3373_3473 3373 3473 6.647039e+00
R_3473_3573 3473 3573 8.771121e+00
R_3573_3673 3573 3673 4.492169e+00
R_3673_3773 3673 3773 2.191436e+00
R_3773_3873 3773 3873 3.671953e+00
R_3873_3973 3873 3973 9.136544e+00
R_3973_4073 3973 4073 4.662551e+00
R_4073_4173 4073 4173 7.438730e-01
R_4173_4273 4173 4273 7.521326e+00
R_4273_4373 4273 4373 6.014957e+00
R_4373_4473 4373 4473 6.824013e+00
R_4473_4573 4473 4573 6.970260e+00
R_4573_4673 4573 4673 4.807228e+00
R_4673_4773 4673 4773 5.855882e+00
R_4773_4873 4773 4873 7.025296e+00
R_4873_4973 4873 4973 1.963399e+00
R_4973_5073 4973 5073 2.031204e+00
R_5073_5173 5073 5173 1.134947e+00
R_5173_5273 5173 5273 2.178220e+00
R_5273_5373 5273 5373 7.774752e+00
R_5373_5473 5373 5473 9.285929e+00
R_5473_5573 5473 5573 3.840559e+00
R_5573_5673 5573 5673 4.591724e+00
R_5673_5773 5673 5773 6.144013e+00
R_5773_5873 5773 5873 6.382653e+00
R_5873_5973 5873 5973 7.616004e+00
R_5973_6073 5973 6073 7.578616e+00
R_6073_6173 6073 6173 6.060263e+00
R_6173_6273 6173 6273 5.787742e+00
R_6273_6373 6273 6373 2.544559e+00
R_6373_6473 6373 6473 7.024579e+00
R_6473_6573 6473 6573 8.860196e+00
R_6573_6673 6573 6673 2.955297e+00
R_6673_6773 6673 6773 7.484456e+00
R_6773_6873 6773 6873 4.130506e+00
R_6873_6973 6873 6973 6.417569e+00
R_6973_7073 6973 7073 9.142711e-01
R_7073_7173 7073 7173 4.567636e+00
R_7173_7273 7173 7273 3.213014e+00
R_7273_7373 7273 7373 2.175383e+00
R_7373_7473 7373 7473 5.871133e+00
R_7473_7573 7473 7573 4.960208e+00
R_7573_7673 7573 7673 2.175983e+00
R_7673_7773 7673 7773 5.569208e+00
R_7773_7873 7773 7873 1.142407e+00
R_7873_7973 7873 7973 6.933585e+00
R_7973_8073 7973 8073 6.297620e+00
R_8073_8173 8073 8173 8.604062e+00
R_8173_8273 8173 8273 9.087524e+00
R_8273_8373 8273 8373 3.815717e+00
R_8373_8473 8373 8473 8.037931e+00
R_8473_8573 8473 8573 5.657603e+00
R_8573_8673 8573 8673 5.067542e+00
R_8673_8773 8673 8773 2.526928e+00
R_8773_8873 8773 8873 6.230736e+00
R_8873_8973 8873 8973 2.496411e+00
R_8973_9073 8973 9073 4.115140e+00
R_9073_9173 9073 9173 9.401527e+00
R_9173_9273 9173 9273 3.213769e+00
R_9273_9373 9273 9373 7.173075e+00
R_9373_9473 9373 9473 8.286413e+00
R_9473_9573 9473 9573 5.648662e+00
R_9573_9673 9573 9673 1.263174e+00
R_9673_9773 9673 9773 5.431145e+00
R_9773_9873 9773 9873 8.894697e+00
R_9873_9973 9873 9973 7.845047e+00
R_74_174 74 174 9.568631e+00
R_174_274 174 274 4.494985e+00
R_274_374 274 374 8.414156e+00
R_374_474 374 474 8.745300e+00
R_474_574 474 574 3.776984e+00
R_574_674 574 674 1.966231e+00
R_674_774 674 774 2.828471e+00
R_774_874 774 874 8.338377e+00
R_874_974 874 974 1.530171e+00
R_974_1074 974 1074 1.967109e+00
R_1074_1174 1074 1174 1.557619e+00
R_1174_1274 1174 1274 1.172546e+00
R_1274_1374 1274 1374 2.391969e+00
R_1374_1474 1374 1474 3.399796e+00
R_1474_1574 1474 1574 1.945543e+00
R_1574_1674 1574 1674 4.051350e+00
R_1674_1774 1674 1774 7.934189e-01
R_1774_1874 1774 1874 4.937156e+00
R_1874_1974 1874 1974 9.015475e+00
R_1974_2074 1974 2074 2.312082e+00
R_2074_2174 2074 2174 2.550533e+00
R_2174_2274 2174 2274 1.680510e+00
R_2274_2374 2274 2374 5.995785e+00
R_2374_2474 2374 2474 2.710343e-01
R_2474_2574 2474 2574 3.582776e+00
R_2574_2674 2574 2674 1.160392e+00
R_2674_2774 2674 2774 6.945511e-01
R_2774_2874 2774 2874 3.744719e-01
R_2874_2974 2874 2974 4.529155e+00
R_2974_3074 2974 3074 9.052497e+00
R_3074_3174 3074 3174 8.989594e+00
R_3174_3274 3174 3274 8.324023e+00
R_3274_3374 3274 3374 1.296565e+00
R_3374_3474 3374 3474 8.602314e+00
R_3474_3574 3474 3574 5.294680e+00
R_3574_3674 3574 3674 2.078710e+00
R_3674_3774 3674 3774 1.196418e-01
R_3774_3874 3774 3874 3.952816e+00
R_3874_3974 3874 3974 2.542347e+00
R_3974_4074 3974 4074 3.243087e-01
R_4074_4174 4074 4174 7.215994e+00
R_4174_4274 4174 4274 3.094872e+00
R_4274_4374 4274 4374 1.385880e+00
R_4374_4474 4374 4474 3.003827e+00
R_4474_4574 4474 4574 8.557756e+00
R_4574_4674 4574 4674 5.785031e+00
R_4674_4774 4674 4774 5.799472e+00
R_4774_4874 4774 4874 3.384791e+00
R_4874_4974 4874 4974 4.820344e+00
R_4974_5074 4974 5074 8.835432e-01
R_5074_5174 5074 5174 3.981225e+00
R_5174_5274 5174 5274 6.632286e+00
R_5274_5374 5274 5374 5.971632e+00
R_5374_5474 5374 5474 5.993812e+00
R_5474_5574 5474 5574 4.118113e+00
R_5574_5674 5574 5674 9.713072e-01
R_5674_5774 5674 5774 3.300494e+00
R_5774_5874 5774 5874 6.494537e+00
R_5874_5974 5874 5974 7.891336e+00
R_5974_6074 5974 6074 8.104521e+00
R_6074_6174 6074 6174 7.442165e+00
R_6174_6274 6174 6274 3.566143e-01
R_6274_6374 6274 6374 8.468434e+00
R_6374_6474 6374 6474 6.749401e+00
R_6474_6574 6474 6574 9.870068e+00
R_6574_6674 6574 6674 9.629265e+00
R_6674_6774 6674 6774 7.242467e+00
R_6774_6874 6774 6874 7.026928e+00
R_6874_6974 6874 6974 2.746192e+00
R_6974_7074 6974 7074 8.015628e-01
R_7074_7174 7074 7174 3.581957e+00
R_7174_7274 7174 7274 6.981789e+00
R_7274_7374 7274 7374 3.861015e-01
R_7374_7474 7374 7474 1.251048e-01
R_7474_7574 7474 7574 6.574318e+00
R_7574_7674 7574 7674 3.408828e+00
R_7674_7774 7674 7774 8.050233e+00
R_7774_7874 7774 7874 2.445459e+00
R_7874_7974 7874 7974 5.293214e+00
R_7974_8074 7974 8074 1.062618e+00
R_8074_8174 8074 8174 4.098628e-01
R_8174_8274 8174 8274 6.310469e+00
R_8274_8374 8274 8374 5.656714e+00
R_8374_8474 8374 8474 4.249450e+00
R_8474_8574 8474 8574 5.340320e+00
R_8574_8674 8574 8674 2.611901e+00
R_8674_8774 8674 8774 4.675012e+00
R_8774_8874 8774 8874 2.548230e-01
R_8874_8974 8874 8974 2.110692e+00
R_8974_9074 8974 9074 1.222494e+00
R_9074_9174 9074 9174 2.879383e+00
R_9174_9274 9174 9274 2.285568e+00
R_9274_9374 9274 9374 2.099502e-01
R_9374_9474 9374 9474 2.017352e+00
R_9474_9574 9474 9574 3.891568e+00
R_9574_9674 9574 9674 8.598449e+00
R_9674_9774 9674 9774 8.313810e+00
R_9774_9874 9774 9874 5.044373e+00
R_9874_9974 9874 9974 6.881500e-02
R_75_175 75 175 2.018809e+00
R_175_275 175 275 1.768650e+00
R_275_375 275 375 3.529723e+00
R_375_475 375 475 2.088672e+00
R_475_575 475 575 2.713456e+00
R_575_675 575 675 2.597712e+00
R_675_775 675 775 8.517555e-01
R_775_875 775 875 5.471483e+00
R_875_975 875 975 8.805087e+00
R_975_1075 975 1075 7.740189e+00
R_1075_1175 1075 1175 1.975832e+00
R_1175_1275 1175 1275 8.688440e+00
R_1275_1375 1275 1375 4.610082e+00
R_1375_1475 1375 1475 4.127122e+00
R_1475_1575 1475 1575 7.223597e+00
R_1575_1675 1575 1675 6.330619e+00
R_1675_1775 1675 1775 6.313228e+00
R_1775_1875 1775 1875 7.150348e+00
R_1875_1975 1875 1975 2.125368e+00
R_1975_2075 1975 2075 3.447801e+00
R_2075_2175 2075 2175 3.814809e+00
R_2175_2275 2175 2275 6.605821e+00
R_2275_2375 2275 2375 1.553823e+00
R_2375_2475 2375 2475 8.903330e+00
R_2475_2575 2475 2575 8.229057e+00
R_2575_2675 2575 2675 4.486023e+00
R_2675_2775 2675 2775 5.454236e+00
R_2775_2875 2775 2875 9.537938e+00
R_2875_2975 2875 2975 8.795980e+00
R_2975_3075 2975 3075 4.649333e+00
R_3075_3175 3075 3175 5.853053e+00
R_3175_3275 3175 3275 3.529308e+00
R_3275_3375 3275 3375 2.674950e+00
R_3375_3475 3375 3475 5.533469e+00
R_3475_3575 3475 3575 3.277755e+00
R_3575_3675 3575 3675 5.157728e+00
R_3675_3775 3675 3775 4.659045e+00
R_3775_3875 3775 3875 3.972618e+00
R_3875_3975 3875 3975 8.972283e+00
R_3975_4075 3975 4075 1.901896e+00
R_4075_4175 4075 4175 7.554961e+00
R_4175_4275 4175 4275 2.282147e+00
R_4275_4375 4275 4375 1.926657e+00
R_4375_4475 4375 4475 5.858106e+00
R_4475_4575 4475 4575 6.615756e+00
R_4575_4675 4575 4675 3.463392e+00
R_4675_4775 4675 4775 3.831893e+00
R_4775_4875 4775 4875 4.058847e-01
R_4875_4975 4875 4975 5.709599e+00
R_4975_5075 4975 5075 1.396181e+00
R_5075_5175 5075 5175 9.947808e+00
R_5175_5275 5175 5275 9.979774e+00
R_5275_5375 5275 5375 6.320167e+00
R_5375_5475 5375 5475 7.099384e+00
R_5475_5575 5475 5575 9.574780e-01
R_5575_5675 5575 5675 5.505636e+00
R_5675_5775 5675 5775 3.561765e+00
R_5775_5875 5775 5875 8.671007e+00
R_5875_5975 5875 5975 6.236440e+00
R_5975_6075 5975 6075 7.443875e+00
R_6075_6175 6075 6175 1.403857e+00
R_6175_6275 6175 6275 6.846748e+00
R_6275_6375 6275 6375 5.303620e+00
R_6375_6475 6375 6475 4.906415e+00
R_6475_6575 6475 6575 9.784437e+00
R_6575_6675 6575 6675 2.989348e+00
R_6675_6775 6675 6775 3.804276e+00
R_6775_6875 6775 6875 3.911262e+00
R_6875_6975 6875 6975 7.548997e+00
R_6975_7075 6975 7075 4.590234e+00
R_7075_7175 7075 7175 9.415575e+00
R_7175_7275 7175 7275 6.775764e+00
R_7275_7375 7275 7375 1.047042e+00
R_7375_7475 7375 7475 3.680768e+00
R_7475_7575 7475 7575 7.911638e+00
R_7575_7675 7575 7675 4.079602e+00
R_7675_7775 7675 7775 2.552561e+00
R_7775_7875 7775 7875 1.279203e+00
R_7875_7975 7875 7975 5.789406e+00
R_7975_8075 7975 8075 8.851203e+00
R_8075_8175 8075 8175 8.264725e+00
R_8175_8275 8175 8275 2.589074e+00
R_8275_8375 8275 8375 7.293126e+00
R_8375_8475 8375 8475 6.239331e+00
R_8475_8575 8475 8575 7.412224e+00
R_8575_8675 8575 8675 5.459575e+00
R_8675_8775 8675 8775 9.405434e-01
R_8775_8875 8775 8875 8.882538e-01
R_8875_8975 8875 8975 9.626145e-01
R_8975_9075 8975 9075 1.158255e+00
R_9075_9175 9075 9175 5.464736e+00
R_9175_9275 9175 9275 4.016109e+00
R_9275_9375 9275 9375 7.158055e+00
R_9375_9475 9375 9475 5.005013e-01
R_9475_9575 9475 9575 9.863997e-01
R_9575_9675 9575 9675 1.790185e+00
R_9675_9775 9675 9775 5.618423e+00
R_9775_9875 9775 9875 6.876228e+00
R_9875_9975 9875 9975 5.639276e+00
R_76_176 76 176 6.440130e+00
R_176_276 176 276 6.579666e+00
R_276_376 276 376 8.453688e+00
R_376_476 376 476 2.884704e+00
R_476_576 476 576 6.369236e+00
R_576_676 576 676 7.187521e+00
R_676_776 676 776 2.816102e+00
R_776_876 776 876 7.969522e+00
R_876_976 876 976 7.846341e+00
R_976_1076 976 1076 3.645405e-01
R_1076_1176 1076 1176 8.332305e+00
R_1176_1276 1176 1276 2.295686e+00
R_1276_1376 1276 1376 1.263738e+00
R_1376_1476 1376 1476 7.448773e-01
R_1476_1576 1476 1576 4.317122e+00
R_1576_1676 1576 1676 3.753649e+00
R_1676_1776 1676 1776 6.465073e-01
R_1776_1876 1776 1876 8.694391e+00
R_1876_1976 1876 1976 2.530265e+00
R_1976_2076 1976 2076 1.899057e+00
R_2076_2176 2076 2176 2.576877e+00
R_2176_2276 2176 2276 7.184738e-02
R_2276_2376 2276 2376 2.385133e+00
R_2376_2476 2376 2476 3.449260e+00
R_2476_2576 2476 2576 9.095072e+00
R_2576_2676 2576 2676 7.957343e+00
R_2676_2776 2676 2776 3.342306e+00
R_2776_2876 2776 2876 4.102011e+00
R_2876_2976 2876 2976 1.856164e+00
R_2976_3076 2976 3076 6.982914e+00
R_3076_3176 3076 3176 6.472262e-01
R_3176_3276 3176 3276 8.423363e+00
R_3276_3376 3276 3376 9.762612e+00
R_3376_3476 3376 3476 3.655537e+00
R_3476_3576 3476 3576 9.047619e+00
R_3576_3676 3576 3676 9.734354e+00
R_3676_3776 3676 3776 9.238791e+00
R_3776_3876 3776 3876 3.715621e+00
R_3876_3976 3876 3976 3.538869e+00
R_3976_4076 3976 4076 4.680118e+00
R_4076_4176 4076 4176 7.973882e+00
R_4176_4276 4176 4276 5.934711e-01
R_4276_4376 4276 4376 7.265766e-01
R_4376_4476 4376 4476 1.100366e-01
R_4476_4576 4476 4576 2.030677e+00
R_4576_4676 4576 4676 2.796054e-01
R_4676_4776 4676 4776 1.132188e+00
R_4776_4876 4776 4876 2.788140e+00
R_4876_4976 4876 4976 9.086911e+00
R_4976_5076 4976 5076 8.202502e+00
R_5076_5176 5076 5176 9.687113e+00
R_5176_5276 5176 5276 5.263645e+00
R_5276_5376 5276 5376 8.116553e+00
R_5376_5476 5376 5476 5.884819e+00
R_5476_5576 5476 5576 5.539045e+00
R_5576_5676 5576 5676 7.774511e+00
R_5676_5776 5676 5776 8.055702e+00
R_5776_5876 5776 5876 1.660584e+00
R_5876_5976 5876 5976 1.769121e+00
R_5976_6076 5976 6076 4.666701e+00
R_6076_6176 6076 6176 8.350165e+00
R_6176_6276 6176 6276 1.967197e-01
R_6276_6376 6276 6376 5.517013e+00
R_6376_6476 6376 6476 4.995176e+00
R_6476_6576 6476 6576 7.831100e+00
R_6576_6676 6576 6676 3.526696e+00
R_6676_6776 6676 6776 4.052572e+00
R_6776_6876 6776 6876 2.759084e+00
R_6876_6976 6876 6976 1.593920e+00
R_6976_7076 6976 7076 5.396554e+00
R_7076_7176 7076 7176 1.638346e+00
R_7176_7276 7176 7276 3.442431e+00
R_7276_7376 7276 7376 3.187629e+00
R_7376_7476 7376 7476 4.793967e+00
R_7476_7576 7476 7576 1.633878e+00
R_7576_7676 7576 7676 1.908628e+00
R_7676_7776 7676 7776 9.550714e+00
R_7776_7876 7776 7876 9.302923e-01
R_7876_7976 7876 7976 3.539098e-01
R_7976_8076 7976 8076 3.563255e+00
R_8076_8176 8076 8176 4.778690e+00
R_8176_8276 8176 8276 2.492451e+00
R_8276_8376 8276 8376 8.151355e+00
R_8376_8476 8376 8476 9.985847e+00
R_8476_8576 8476 8576 3.943103e-01
R_8576_8676 8576 8676 8.560900e+00
R_8676_8776 8676 8776 4.429012e+00
R_8776_8876 8776 8876 3.866421e+00
R_8876_8976 8876 8976 5.132643e+00
R_8976_9076 8976 9076 8.551537e+00
R_9076_9176 9076 9176 7.251714e+00
R_9176_9276 9176 9276 2.295140e-01
R_9276_9376 9276 9376 9.872264e+00
R_9376_9476 9376 9476 8.147114e+00
R_9476_9576 9476 9576 8.666232e+00
R_9576_9676 9576 9676 7.260912e-03
R_9676_9776 9676 9776 9.205187e+00
R_9776_9876 9776 9876 6.127986e+00
R_9876_9976 9876 9976 2.730086e+00
R_77_177 77 177 4.525073e+00
R_177_277 177 277 3.418598e+00
R_277_377 277 377 1.120585e+00
R_377_477 377 477 9.081921e+00
R_477_577 477 577 6.501250e+00
R_577_677 577 677 5.884093e+00
R_677_777 677 777 9.068484e-01
R_777_877 777 877 5.619030e+00
R_877_977 877 977 1.947262e+00
R_977_1077 977 1077 9.626854e+00
R_1077_1177 1077 1177 4.624011e+00
R_1177_1277 1177 1277 7.984438e+00
R_1277_1377 1277 1377 8.464236e+00
R_1377_1477 1377 1477 4.346033e+00
R_1477_1577 1477 1577 4.135381e+00
R_1577_1677 1577 1677 7.358176e+00
R_1677_1777 1677 1777 4.826113e-01
R_1777_1877 1777 1877 8.271481e+00
R_1877_1977 1877 1977 5.593197e+00
R_1977_2077 1977 2077 5.668623e-01
R_2077_2177 2077 2177 6.986408e+00
R_2177_2277 2177 2277 8.338065e+00
R_2277_2377 2277 2377 3.044655e+00
R_2377_2477 2377 2477 7.529333e+00
R_2477_2577 2477 2577 8.272809e+00
R_2577_2677 2577 2677 2.551688e+00
R_2677_2777 2677 2777 8.593665e+00
R_2777_2877 2777 2877 5.398850e+00
R_2877_2977 2877 2977 5.727718e+00
R_2977_3077 2977 3077 3.815412e+00
R_3077_3177 3077 3177 8.240505e+00
R_3177_3277 3177 3277 9.768819e-01
R_3277_3377 3277 3377 2.840585e+00
R_3377_3477 3377 3477 7.206476e+00
R_3477_3577 3477 3577 6.271590e+00
R_3577_3677 3577 3677 5.284332e+00
R_3677_3777 3677 3777 1.077660e+00
R_3777_3877 3777 3877 4.330661e+00
R_3877_3977 3877 3977 7.903074e+00
R_3977_4077 3977 4077 3.166883e+00
R_4077_4177 4077 4177 8.747883e+00
R_4177_4277 4177 4277 6.177100e+00
R_4277_4377 4277 4377 1.527766e+00
R_4377_4477 4377 4477 7.066966e+00
R_4477_4577 4477 4577 8.538272e+00
R_4577_4677 4577 4677 9.878080e+00
R_4677_4777 4677 4777 3.761311e+00
R_4777_4877 4777 4877 7.926489e-01
R_4877_4977 4877 4977 7.231921e+00
R_4977_5077 4977 5077 2.565550e-01
R_5077_5177 5077 5177 5.015711e+00
R_5177_5277 5177 5277 3.032616e+00
R_5277_5377 5277 5377 7.983696e+00
R_5377_5477 5377 5477 7.131575e+00
R_5477_5577 5477 5577 5.961135e+00
R_5577_5677 5577 5677 8.272399e+00
R_5677_5777 5677 5777 6.969352e+00
R_5777_5877 5777 5877 8.849126e+00
R_5877_5977 5877 5977 6.172233e+00
R_5977_6077 5977 6077 4.057100e+00
R_6077_6177 6077 6177 6.106266e+00
R_6177_6277 6177 6277 7.814294e+00
R_6277_6377 6277 6377 1.936521e+00
R_6377_6477 6377 6477 3.439341e+00
R_6477_6577 6477 6577 5.103961e+00
R_6577_6677 6577 6677 5.405267e+00
R_6677_6777 6677 6777 5.063381e-01
R_6777_6877 6777 6877 9.887795e+00
R_6877_6977 6877 6977 5.907496e+00
R_6977_7077 6977 7077 7.277983e+00
R_7077_7177 7077 7177 4.421470e+00
R_7177_7277 7177 7277 7.323599e+00
R_7277_7377 7277 7377 7.550581e+00
R_7377_7477 7377 7477 1.688697e+00
R_7477_7577 7477 7577 7.686661e+00
R_7577_7677 7577 7677 2.326058e+00
R_7677_7777 7677 7777 3.178094e+00
R_7777_7877 7777 7877 4.927160e+00
R_7877_7977 7877 7977 3.698698e+00
R_7977_8077 7977 8077 2.804265e+00
R_8077_8177 8077 8177 9.127691e+00
R_8177_8277 8177 8277 9.291599e+00
R_8277_8377 8277 8377 1.506870e-01
R_8377_8477 8377 8477 9.723947e+00
R_8477_8577 8477 8577 9.395991e+00
R_8577_8677 8577 8677 3.330264e+00
R_8677_8777 8677 8777 6.993788e+00
R_8777_8877 8777 8877 2.528982e+00
R_8877_8977 8877 8977 7.661675e+00
R_8977_9077 8977 9077 3.696205e+00
R_9077_9177 9077 9177 4.585118e+00
R_9177_9277 9177 9277 2.501173e+00
R_9277_9377 9277 9377 5.134338e-01
R_9377_9477 9377 9477 5.370786e+00
R_9477_9577 9477 9577 9.498507e+00
R_9577_9677 9577 9677 7.214229e-01
R_9677_9777 9677 9777 7.816333e+00
R_9777_9877 9777 9877 9.387208e+00
R_9877_9977 9877 9977 1.544366e+00
R_78_178 78 178 8.237276e+00
R_178_278 178 278 6.697946e+00
R_278_378 278 378 9.825069e+00
R_378_478 378 478 7.731880e+00
R_478_578 478 578 1.809833e+00
R_578_678 578 678 2.471926e+00
R_678_778 678 778 5.745033e+00
R_778_878 778 878 8.971647e-01
R_878_978 878 978 9.556366e+00
R_978_1078 978 1078 4.203311e+00
R_1078_1178 1078 1178 4.431816e+00
R_1178_1278 1178 1278 1.135214e+00
R_1278_1378 1278 1378 3.960658e+00
R_1378_1478 1378 1478 2.320616e+00
R_1478_1578 1478 1578 2.615583e+00
R_1578_1678 1578 1678 2.864523e+00
R_1678_1778 1678 1778 2.222334e+00
R_1778_1878 1778 1878 3.156439e-01
R_1878_1978 1878 1978 9.150071e+00
R_1978_2078 1978 2078 1.600685e+00
R_2078_2178 2078 2178 1.068257e+00
R_2178_2278 2178 2278 9.461993e+00
R_2278_2378 2278 2378 2.643997e+00
R_2378_2478 2378 2478 8.061454e+00
R_2478_2578 2478 2578 7.724996e+00
R_2578_2678 2578 2678 4.552393e+00
R_2678_2778 2678 2778 7.889694e+00
R_2778_2878 2778 2878 7.411733e-01
R_2878_2978 2878 2978 9.603033e+00
R_2978_3078 2978 3078 4.238769e+00
R_3078_3178 3078 3178 3.598966e-01
R_3178_3278 3178 3278 7.976179e+00
R_3278_3378 3278 3378 5.608138e-01
R_3378_3478 3378 3478 5.961076e+00
R_3478_3578 3478 3578 6.020443e+00
R_3578_3678 3578 3678 3.475698e+00
R_3678_3778 3678 3778 2.591956e-01
R_3778_3878 3778 3878 3.421749e+00
R_3878_3978 3878 3978 8.088768e+00
R_3978_4078 3978 4078 3.313536e+00
R_4078_4178 4078 4178 1.001960e+00
R_4178_4278 4178 4278 9.650717e+00
R_4278_4378 4278 4378 3.244010e+00
R_4378_4478 4378 4478 1.402060e+00
R_4478_4578 4478 4578 6.569941e+00
R_4578_4678 4578 4678 3.889226e+00
R_4678_4778 4678 4778 7.071643e+00
R_4778_4878 4778 4878 9.617814e+00
R_4878_4978 4878 4978 3.093716e+00
R_4978_5078 4978 5078 7.824393e+00
R_5078_5178 5078 5178 2.486830e+00
R_5178_5278 5178 5278 2.726370e+00
R_5278_5378 5278 5378 5.339408e+00
R_5378_5478 5378 5478 2.710658e+00
R_5478_5578 5478 5578 6.559746e+00
R_5578_5678 5578 5678 3.647147e+00
R_5678_5778 5678 5778 3.451392e+00
R_5778_5878 5778 5878 4.577028e+00
R_5878_5978 5878 5978 1.997579e+00
R_5978_6078 5978 6078 2.475593e+00
R_6078_6178 6078 6178 4.019933e+00
R_6178_6278 6178 6278 8.560499e+00
R_6278_6378 6278 6378 7.185891e+00
R_6378_6478 6378 6478 3.589983e+00
R_6478_6578 6478 6578 6.916442e+00
R_6578_6678 6578 6678 9.486591e-01
R_6678_6778 6678 6778 6.568141e-01
R_6778_6878 6778 6878 1.717965e+00
R_6878_6978 6878 6978 4.697871e+00
R_6978_7078 6978 7078 7.030151e+00
R_7078_7178 7078 7178 8.464510e+00
R_7178_7278 7178 7278 1.844547e+00
R_7278_7378 7278 7378 3.934156e+00
R_7378_7478 7378 7478 6.584117e+00
R_7478_7578 7478 7578 4.689761e+00
R_7578_7678 7578 7678 8.461940e+00
R_7678_7778 7678 7778 9.160175e-01
R_7778_7878 7778 7878 4.126986e+00
R_7878_7978 7878 7978 3.412493e+00
R_7978_8078 7978 8078 6.794096e+00
R_8078_8178 8078 8178 3.829235e+00
R_8178_8278 8178 8278 3.731504e+00
R_8278_8378 8278 8378 8.540709e+00
R_8378_8478 8378 8478 1.994670e-01
R_8478_8578 8478 8578 6.631149e+00
R_8578_8678 8578 8678 7.624645e+00
R_8678_8778 8678 8778 9.102214e+00
R_8778_8878 8778 8878 2.233526e+00
R_8878_8978 8878 8978 2.846763e+00
R_8978_9078 8978 9078 1.767852e-01
R_9078_9178 9078 9178 1.599971e+00
R_9178_9278 9178 9278 4.277521e-01
R_9278_9378 9278 9378 4.362760e+00
R_9378_9478 9378 9478 2.234482e+00
R_9478_9578 9478 9578 9.296024e+00
R_9578_9678 9578 9678 6.684253e+00
R_9678_9778 9678 9778 1.751993e+00
R_9778_9878 9778 9878 7.770115e+00
R_9878_9978 9878 9978 3.472419e+00
R_79_179 79 179 4.915109e+00
R_179_279 179 279 2.751385e+00
R_279_379 279 379 6.641738e+00
R_379_479 379 479 7.440344e+00
R_479_579 479 579 4.695377e+00
R_579_679 579 679 2.317820e+00
R_679_779 679 779 1.226672e+00
R_779_879 779 879 9.189762e+00
R_879_979 879 979 9.234606e-01
R_979_1079 979 1079 3.838726e-01
R_1079_1179 1079 1179 7.698393e+00
R_1179_1279 1179 1279 8.827252e+00
R_1279_1379 1279 1379 3.594709e+00
R_1379_1479 1379 1479 8.798051e+00
R_1479_1579 1479 1579 7.115372e+00
R_1579_1679 1579 1679 8.459481e+00
R_1679_1779 1679 1779 1.716038e+00
R_1779_1879 1779 1879 2.994464e+00
R_1879_1979 1879 1979 1.007340e+00
R_1979_2079 1979 2079 9.135705e+00
R_2079_2179 2079 2179 9.556125e+00
R_2179_2279 2179 2279 1.842633e-01
R_2279_2379 2279 2379 5.027100e+00
R_2379_2479 2379 2479 9.878372e+00
R_2479_2579 2479 2579 9.123355e+00
R_2579_2679 2579 2679 1.187430e+00
R_2679_2779 2679 2779 6.007094e+00
R_2779_2879 2779 2879 1.814448e+00
R_2879_2979 2879 2979 1.552811e-01
R_2979_3079 2979 3079 1.506032e+00
R_3079_3179 3079 3179 7.536006e+00
R_3179_3279 3179 3279 8.690344e+00
R_3279_3379 3279 3379 2.544752e+00
R_3379_3479 3379 3479 6.331257e+00
R_3479_3579 3479 3579 6.453034e+00
R_3579_3679 3579 3679 7.757498e-01
R_3679_3779 3679 3779 3.157907e+00
R_3779_3879 3779 3879 1.073923e-01
R_3879_3979 3879 3979 3.694918e-01
R_3979_4079 3979 4079 1.580734e-01
R_4079_4179 4079 4179 3.925714e+00
R_4179_4279 4179 4279 1.884425e+00
R_4279_4379 4279 4379 8.328814e+00
R_4379_4479 4379 4479 8.870403e+00
R_4479_4579 4479 4579 6.337717e+00
R_4579_4679 4579 4679 5.018109e+00
R_4679_4779 4679 4779 1.770604e+00
R_4779_4879 4779 4879 6.418774e+00
R_4879_4979 4879 4979 6.122621e+00
R_4979_5079 4979 5079 4.093622e+00
R_5079_5179 5079 5179 7.981290e+00
R_5179_5279 5179 5279 8.079299e+00
R_5279_5379 5279 5379 7.509373e+00
R_5379_5479 5379 5479 5.686182e+00
R_5479_5579 5479 5579 3.266567e-01
R_5579_5679 5579 5679 6.473433e-01
R_5679_5779 5679 5779 3.992357e+00
R_5779_5879 5779 5879 1.157042e+00
R_5879_5979 5879 5979 6.697464e+00
R_5979_6079 5979 6079 7.563030e+00
R_6079_6179 6079 6179 8.176180e+00
R_6179_6279 6179 6279 4.461475e+00
R_6279_6379 6279 6379 2.556418e+00
R_6379_6479 6379 6479 7.187115e+00
R_6479_6579 6479 6579 5.041924e+00
R_6579_6679 6579 6679 8.706411e+00
R_6679_6779 6679 6779 9.556376e+00
R_6779_6879 6779 6879 4.850716e+00
R_6879_6979 6879 6979 1.076916e+00
R_6979_7079 6979 7079 3.131357e+00
R_7079_7179 7079 7179 6.562433e+00
R_7179_7279 7179 7279 9.656910e+00
R_7279_7379 7279 7379 9.126569e+00
R_7379_7479 7379 7479 8.977303e+00
R_7479_7579 7479 7579 2.099988e+00
R_7579_7679 7579 7679 8.263999e+00
R_7679_7779 7679 7779 9.471927e+00
R_7779_7879 7779 7879 7.583253e+00
R_7879_7979 7879 7979 7.125181e+00
R_7979_8079 7979 8079 6.436438e+00
R_8079_8179 8079 8179 4.294676e+00
R_8179_8279 8179 8279 6.911638e+00
R_8279_8379 8279 8379 4.809537e+00
R_8379_8479 8379 8479 7.276376e+00
R_8479_8579 8479 8579 1.484303e+00
R_8579_8679 8579 8679 7.220121e+00
R_8679_8779 8679 8779 4.564984e+00
R_8779_8879 8779 8879 2.582493e+00
R_8879_8979 8879 8979 8.280256e-01
R_8979_9079 8979 9079 4.148755e+00
R_9079_9179 9079 9179 1.671413e+00
R_9179_9279 9179 9279 2.223195e-01
R_9279_9379 9279 9379 9.228089e+00
R_9379_9479 9379 9479 6.128971e+00
R_9479_9579 9479 9579 4.305334e+00
R_9579_9679 9579 9679 3.821844e+00
R_9679_9779 9679 9779 7.395607e+00
R_9779_9879 9779 9879 5.467034e+00
R_9879_9979 9879 9979 1.431792e+00
R_80_180 80 180 5.050688e+00
R_180_280 180 280 3.364404e-01
R_280_380 280 380 3.842417e+00
R_380_480 380 480 8.088414e+00
R_480_580 480 580 4.859796e+00
R_580_680 580 680 2.608298e+00
R_680_780 680 780 8.895651e+00
R_780_880 780 880 3.688016e+00
R_880_980 880 980 2.904733e+00
R_980_1080 980 1080 5.676676e+00
R_1080_1180 1080 1180 5.474949e+00
R_1180_1280 1180 1280 3.876453e+00
R_1280_1380 1280 1380 9.277273e+00
R_1380_1480 1380 1480 2.010877e+00
R_1480_1580 1480 1580 9.930558e+00
R_1580_1680 1580 1680 4.246607e+00
R_1680_1780 1680 1780 2.426387e+00
R_1780_1880 1780 1880 1.041619e+00
R_1880_1980 1880 1980 5.831592e-02
R_1980_2080 1980 2080 2.822663e+00
R_2080_2180 2080 2180 4.707312e-01
R_2180_2280 2180 2280 3.548402e+00
R_2280_2380 2280 2380 1.130819e-01
R_2380_2480 2380 2480 6.156976e+00
R_2480_2580 2480 2580 6.261544e+00
R_2580_2680 2580 2680 8.317383e+00
R_2680_2780 2680 2780 1.280596e+00
R_2780_2880 2780 2880 6.830412e+00
R_2880_2980 2880 2980 8.694972e+00
R_2980_3080 2980 3080 8.873290e+00
R_3080_3180 3080 3180 4.628222e+00
R_3180_3280 3180 3280 6.149302e+00
R_3280_3380 3280 3380 2.283211e+00
R_3380_3480 3380 3480 5.170242e+00
R_3480_3580 3480 3580 3.898465e+00
R_3580_3680 3580 3680 7.117209e+00
R_3680_3780 3680 3780 1.394690e+00
R_3780_3880 3780 3880 5.227594e+00
R_3880_3980 3880 3980 7.383666e+00
R_3980_4080 3980 4080 6.820623e+00
R_4080_4180 4080 4180 8.754434e+00
R_4180_4280 4180 4280 1.947826e+00
R_4280_4380 4280 4380 9.265133e+00
R_4380_4480 4380 4480 2.191158e+00
R_4480_4580 4480 4580 1.457954e+00
R_4580_4680 4580 4680 4.303356e+00
R_4680_4780 4680 4780 1.831379e+00
R_4780_4880 4780 4880 3.697966e+00
R_4880_4980 4880 4980 5.968466e-01
R_4980_5080 4980 5080 5.256136e+00
R_5080_5180 5080 5180 1.694015e+00
R_5180_5280 5180 5280 1.500843e-02
R_5280_5380 5280 5380 7.821046e+00
R_5380_5480 5380 5480 6.072509e+00
R_5480_5580 5480 5580 7.154826e+00
R_5580_5680 5580 5680 6.500205e-01
R_5680_5780 5680 5780 9.809749e+00
R_5780_5880 5780 5880 8.723710e+00
R_5880_5980 5880 5980 9.415748e+00
R_5980_6080 5980 6080 7.324700e+00
R_6080_6180 6080 6180 7.469241e+00
R_6180_6280 6180 6280 8.367264e+00
R_6280_6380 6280 6380 7.932339e+00
R_6380_6480 6380 6480 3.563867e+00
R_6480_6580 6480 6580 6.149359e+00
R_6580_6680 6580 6680 3.180676e+00
R_6680_6780 6680 6780 2.909394e+00
R_6780_6880 6780 6880 8.395763e+00
R_6880_6980 6880 6980 7.397687e+00
R_6980_7080 6980 7080 6.548304e+00
R_7080_7180 7080 7180 1.339833e+00
R_7180_7280 7180 7280 8.401131e+00
R_7280_7380 7280 7380 6.833688e+00
R_7380_7480 7380 7480 9.271828e+00
R_7480_7580 7480 7580 7.237226e+00
R_7580_7680 7580 7680 8.882812e+00
R_7680_7780 7680 7780 6.836734e+00
R_7780_7880 7780 7880 2.000209e+00
R_7880_7980 7880 7980 5.062060e+00
R_7980_8080 7980 8080 1.112426e+00
R_8080_8180 8080 8180 6.114681e+00
R_8180_8280 8180 8280 4.187586e+00
R_8280_8380 8280 8380 8.699949e-01
R_8380_8480 8380 8480 2.090463e-01
R_8480_8580 8480 8580 5.041082e+00
R_8580_8680 8580 8680 4.019487e+00
R_8680_8780 8680 8780 3.778445e+00
R_8780_8880 8780 8880 3.661067e+00
R_8880_8980 8880 8980 8.216982e+00
R_8980_9080 8980 9080 7.359052e+00
R_9080_9180 9080 9180 6.317835e+00
R_9180_9280 9180 9280 2.999294e+00
R_9280_9380 9280 9380 5.428136e+00
R_9380_9480 9380 9480 7.785698e+00
R_9480_9580 9480 9580 5.330853e+00
R_9580_9680 9580 9680 1.925543e+00
R_9680_9780 9680 9780 1.154705e+00
R_9780_9880 9780 9880 8.874744e+00
R_9880_9980 9880 9980 5.944494e+00
R_81_181 81 181 5.619955e+00
R_181_281 181 281 7.295910e+00
R_281_381 281 381 4.088437e+00
R_381_481 381 481 4.756498e+00
R_481_581 481 581 2.168244e+00
R_581_681 581 681 7.625486e+00
R_681_781 681 781 5.808419e+00
R_781_881 781 881 6.271639e+00
R_881_981 881 981 3.772876e+00
R_981_1081 981 1081 3.875127e+00
R_1081_1181 1081 1181 1.238727e+00
R_1181_1281 1181 1281 7.312689e+00
R_1281_1381 1281 1381 4.165865e+00
R_1381_1481 1381 1481 8.278736e+00
R_1481_1581 1481 1581 3.866633e+00
R_1581_1681 1581 1681 8.753605e+00
R_1681_1781 1681 1781 2.332521e+00
R_1781_1881 1781 1881 3.048278e+00
R_1881_1981 1881 1981 7.798552e+00
R_1981_2081 1981 2081 2.967940e+00
R_2081_2181 2081 2181 6.855464e+00
R_2181_2281 2181 2281 7.746964e+00
R_2281_2381 2281 2381 8.823207e+00
R_2381_2481 2381 2481 9.078225e-01
R_2481_2581 2481 2581 9.814723e+00
R_2581_2681 2581 2681 5.933281e+00
R_2681_2781 2681 2781 1.586230e-01
R_2781_2881 2781 2881 4.376942e+00
R_2881_2981 2881 2981 4.534704e+00
R_2981_3081 2981 3081 1.662362e+00
R_3081_3181 3081 3181 1.626659e+00
R_3181_3281 3181 3281 6.773582e+00
R_3281_3381 3281 3381 6.154624e-01
R_3381_3481 3381 3481 2.130611e+00
R_3481_3581 3481 3581 7.583118e+00
R_3581_3681 3581 3681 2.698785e+00
R_3681_3781 3681 3781 2.945104e+00
R_3781_3881 3781 3881 7.892651e+00
R_3881_3981 3881 3981 1.314466e+00
R_3981_4081 3981 4081 1.549091e+00
R_4081_4181 4081 4181 8.553513e-02
R_4181_4281 4181 4281 3.412155e-01
R_4281_4381 4281 4381 8.281949e+00
R_4381_4481 4381 4481 7.640824e+00
R_4481_4581 4481 4581 3.290543e+00
R_4581_4681 4581 4681 7.392022e+00
R_4681_4781 4681 4781 8.445478e+00
R_4781_4881 4781 4881 2.550330e+00
R_4881_4981 4881 4981 9.310722e+00
R_4981_5081 4981 5081 3.177509e+00
R_5081_5181 5081 5181 2.268661e+00
R_5181_5281 5181 5281 2.996594e+00
R_5281_5381 5281 5381 6.990661e-02
R_5381_5481 5381 5481 3.717972e+00
R_5481_5581 5481 5581 5.049122e+00
R_5581_5681 5581 5681 5.504033e+00
R_5681_5781 5681 5781 1.891447e-01
R_5781_5881 5781 5881 8.479657e+00
R_5881_5981 5881 5981 2.426267e-01
R_5981_6081 5981 6081 9.901711e+00
R_6081_6181 6081 6181 1.634950e+00
R_6181_6281 6181 6281 5.094738e+00
R_6281_6381 6281 6381 9.056871e+00
R_6381_6481 6381 6481 9.371533e+00
R_6481_6581 6481 6581 8.147074e+00
R_6581_6681 6581 6681 7.700455e+00
R_6681_6781 6681 6781 8.200470e+00
R_6781_6881 6781 6881 9.327869e+00
R_6881_6981 6881 6981 4.099111e+00
R_6981_7081 6981 7081 7.505970e-01
R_7081_7181 7081 7181 7.623396e+00
R_7181_7281 7181 7281 7.652066e+00
R_7281_7381 7281 7381 4.569753e+00
R_7381_7481 7381 7481 7.331745e+00
R_7481_7581 7481 7581 7.010580e+00
R_7581_7681 7581 7681 8.393342e+00
R_7681_7781 7681 7781 8.674137e+00
R_7781_7881 7781 7881 2.652783e+00
R_7881_7981 7881 7981 7.090468e+00
R_7981_8081 7981 8081 8.531534e+00
R_8081_8181 8081 8181 9.860104e+00
R_8181_8281 8181 8281 2.539355e+00
R_8281_8381 8281 8381 8.849488e+00
R_8381_8481 8381 8481 2.873990e+00
R_8481_8581 8481 8581 3.712896e+00
R_8581_8681 8581 8681 6.725907e+00
R_8681_8781 8681 8781 7.885268e+00
R_8781_8881 8781 8881 7.052250e+00
R_8881_8981 8881 8981 2.590217e+00
R_8981_9081 8981 9081 9.057452e+00
R_9081_9181 9081 9181 9.415649e+00
R_9181_9281 9181 9281 3.673142e+00
R_9281_9381 9281 9381 9.768732e+00
R_9381_9481 9381 9481 2.826145e+00
R_9481_9581 9481 9581 1.541409e+00
R_9581_9681 9581 9681 5.837518e+00
R_9681_9781 9681 9781 9.261123e+00
R_9781_9881 9781 9881 4.892223e+00
R_9881_9981 9881 9981 4.402202e+00
R_82_182 82 182 6.185063e+00
R_182_282 182 282 2.617690e+00
R_282_382 282 382 9.747516e+00
R_382_482 382 482 6.942518e+00
R_482_582 482 582 8.913036e+00
R_582_682 582 682 6.842187e+00
R_682_782 682 782 1.041956e+00
R_782_882 782 882 1.747377e-01
R_882_982 882 982 5.595209e+00
R_982_1082 982 1082 3.730690e+00
R_1082_1182 1082 1182 3.209187e+00
R_1182_1282 1182 1282 7.980260e+00
R_1282_1382 1282 1382 8.241651e+00
R_1382_1482 1382 1482 6.479250e+00
R_1482_1582 1482 1582 3.524152e+00
R_1582_1682 1582 1682 6.890088e+00
R_1682_1782 1682 1782 2.461313e+00
R_1782_1882 1782 1882 4.928957e+00
R_1882_1982 1882 1982 5.140508e+00
R_1982_2082 1982 2082 1.688138e+00
R_2082_2182 2082 2182 6.883053e+00
R_2182_2282 2182 2282 5.458404e+00
R_2282_2382 2282 2382 3.429848e-01
R_2382_2482 2382 2482 3.578442e-01
R_2482_2582 2482 2582 4.956002e+00
R_2582_2682 2582 2682 4.778832e+00
R_2682_2782 2682 2782 5.821530e+00
R_2782_2882 2782 2882 8.707699e+00
R_2882_2982 2882 2982 9.862431e+00
R_2982_3082 2982 3082 7.167887e+00
R_3082_3182 3082 3182 9.593594e+00
R_3182_3282 3182 3282 7.699785e+00
R_3282_3382 3282 3382 3.090603e+00
R_3382_3482 3382 3482 8.696269e-01
R_3482_3582 3482 3582 1.598623e+00
R_3582_3682 3582 3682 6.577308e-01
R_3682_3782 3682 3782 8.159026e+00
R_3782_3882 3782 3882 6.155769e+00
R_3882_3982 3882 3982 6.245407e+00
R_3982_4082 3982 4082 3.615572e+00
R_4082_4182 4082 4182 9.174284e+00
R_4182_4282 4182 4282 3.624026e+00
R_4282_4382 4282 4382 2.722521e+00
R_4382_4482 4382 4482 1.985268e+00
R_4482_4582 4482 4582 4.689352e+00
R_4582_4682 4582 4682 4.381782e+00
R_4682_4782 4682 4782 1.846600e+00
R_4782_4882 4782 4882 8.249516e+00
R_4882_4982 4882 4982 1.688147e+00
R_4982_5082 4982 5082 5.561816e+00
R_5082_5182 5082 5182 7.776867e-01
R_5182_5282 5182 5282 4.176839e+00
R_5282_5382 5282 5382 6.166888e+00
R_5382_5482 5382 5482 5.754567e+00
R_5482_5582 5482 5582 3.200291e+00
R_5582_5682 5582 5682 1.590311e+00
R_5682_5782 5682 5782 6.292003e-01
R_5782_5882 5782 5882 7.349342e+00
R_5882_5982 5882 5982 2.960368e+00
R_5982_6082 5982 6082 2.547073e+00
R_6082_6182 6082 6182 2.601272e+00
R_6182_6282 6182 6282 7.251885e-01
R_6282_6382 6282 6382 4.402610e+00
R_6382_6482 6382 6482 4.548564e+00
R_6482_6582 6482 6582 8.213975e+00
R_6582_6682 6582 6682 5.299912e+00
R_6682_6782 6682 6782 7.403519e+00
R_6782_6882 6782 6882 6.535729e+00
R_6882_6982 6882 6982 2.486495e+00
R_6982_7082 6982 7082 8.478943e-01
R_7082_7182 7082 7182 1.412300e-01
R_7182_7282 7182 7282 1.627681e+00
R_7282_7382 7282 7382 5.298999e+00
R_7382_7482 7382 7482 5.366051e+00
R_7482_7582 7482 7582 2.142863e+00
R_7582_7682 7582 7682 1.035716e+00
R_7682_7782 7682 7782 2.117795e+00
R_7782_7882 7782 7882 3.379762e+00
R_7882_7982 7882 7982 7.854368e+00
R_7982_8082 7982 8082 9.403649e+00
R_8082_8182 8082 8182 2.903814e+00
R_8182_8282 8182 8282 8.108976e+00
R_8282_8382 8282 8382 4.039086e+00
R_8382_8482 8382 8482 1.461463e+00
R_8482_8582 8482 8582 1.455685e+00
R_8582_8682 8582 8682 3.283953e+00
R_8682_8782 8682 8782 8.236974e-01
R_8782_8882 8782 8882 5.189900e+00
R_8882_8982 8882 8982 6.581317e+00
R_8982_9082 8982 9082 3.562152e+00
R_9082_9182 9082 9182 6.700360e+00
R_9182_9282 9182 9282 7.405748e+00
R_9282_9382 9282 9382 8.589843e-01
R_9382_9482 9382 9482 4.118419e+00
R_9482_9582 9482 9582 9.125617e+00
R_9582_9682 9582 9682 3.988324e+00
R_9682_9782 9682 9782 6.916363e+00
R_9782_9882 9782 9882 9.511953e+00
R_9882_9982 9882 9982 3.136625e+00
R_83_183 83 183 1.699469e+00
R_183_283 183 283 7.915978e+00
R_283_383 283 383 3.124879e+00
R_383_483 383 483 8.294487e+00
R_483_583 483 583 5.631067e+00
R_583_683 583 683 1.419728e+00
R_683_783 683 783 4.439579e+00
R_783_883 783 883 6.903740e+00
R_883_983 883 983 2.670034e-01
R_983_1083 983 1083 1.982450e+00
R_1083_1183 1083 1183 3.232638e+00
R_1183_1283 1183 1283 7.547618e+00
R_1283_1383 1283 1383 5.788507e+00
R_1383_1483 1383 1483 1.475262e+00
R_1483_1583 1483 1583 2.425049e+00
R_1583_1683 1583 1683 1.431454e+00
R_1683_1783 1683 1783 2.628415e+00
R_1783_1883 1783 1883 3.464144e+00
R_1883_1983 1883 1983 3.237064e+00
R_1983_2083 1983 2083 3.783250e+00
R_2083_2183 2083 2183 8.260444e-01
R_2183_2283 2183 2283 7.980615e+00
R_2283_2383 2283 2383 3.232358e-01
R_2383_2483 2383 2483 3.181655e+00
R_2483_2583 2483 2583 2.100814e+00
R_2583_2683 2583 2683 8.835203e+00
R_2683_2783 2683 2783 7.136156e+00
R_2783_2883 2783 2883 8.754083e+00
R_2883_2983 2883 2983 3.860779e+00
R_2983_3083 2983 3083 3.069888e-01
R_3083_3183 3083 3183 2.252328e+00
R_3183_3283 3183 3283 9.302778e+00
R_3283_3383 3283 3383 4.294945e-01
R_3383_3483 3383 3483 5.087827e+00
R_3483_3583 3483 3583 8.584528e+00
R_3583_3683 3583 3683 1.474176e+00
R_3683_3783 3683 3783 8.062796e-01
R_3783_3883 3783 3883 3.165258e+00
R_3883_3983 3883 3983 1.983069e+00
R_3983_4083 3983 4083 5.588007e+00
R_4083_4183 4083 4183 3.563842e+00
R_4183_4283 4183 4283 9.777376e+00
R_4283_4383 4283 4383 7.517289e+00
R_4383_4483 4383 4483 4.969973e+00
R_4483_4583 4483 4583 3.041881e+00
R_4583_4683 4583 4683 6.353489e+00
R_4683_4783 4683 4783 4.655776e+00
R_4783_4883 4783 4883 6.906256e-01
R_4883_4983 4883 4983 6.260331e+00
R_4983_5083 4983 5083 4.491135e+00
R_5083_5183 5083 5183 1.206624e+00
R_5183_5283 5183 5283 2.629506e+00
R_5283_5383 5283 5383 1.985059e+00
R_5383_5483 5383 5483 7.970462e+00
R_5483_5583 5483 5583 6.708322e+00
R_5583_5683 5583 5683 6.599200e-01
R_5683_5783 5683 5783 3.666536e+00
R_5783_5883 5783 5883 4.308917e+00
R_5883_5983 5883 5983 7.401229e+00
R_5983_6083 5983 6083 9.500144e+00
R_6083_6183 6083 6183 1.980039e+00
R_6183_6283 6183 6283 7.614790e+00
R_6283_6383 6283 6383 9.294137e+00
R_6383_6483 6383 6483 4.917991e+00
R_6483_6583 6483 6583 2.600330e+00
R_6583_6683 6583 6683 9.313464e-01
R_6683_6783 6683 6783 5.393225e+00
R_6783_6883 6783 6883 5.956226e+00
R_6883_6983 6883 6983 9.358676e+00
R_6983_7083 6983 7083 1.887208e+00
R_7083_7183 7083 7183 1.973926e-01
R_7183_7283 7183 7283 2.026325e+00
R_7283_7383 7283 7383 3.670587e+00
R_7383_7483 7383 7483 9.810036e+00
R_7483_7583 7483 7583 2.275531e-01
R_7583_7683 7583 7683 5.421339e+00
R_7683_7783 7683 7783 1.566653e+00
R_7783_7883 7783 7883 4.432725e+00
R_7883_7983 7883 7983 7.226889e+00
R_7983_8083 7983 8083 1.113066e+00
R_8083_8183 8083 8183 3.975145e+00
R_8183_8283 8183 8283 6.140349e+00
R_8283_8383 8283 8383 6.215508e+00
R_8383_8483 8383 8483 4.285301e+00
R_8483_8583 8483 8583 5.771257e+00
R_8583_8683 8583 8683 7.229537e+00
R_8683_8783 8683 8783 1.506892e+00
R_8783_8883 8783 8883 4.858484e+00
R_8883_8983 8883 8983 5.745808e+00
R_8983_9083 8983 9083 2.364734e-01
R_9083_9183 9083 9183 7.087200e+00
R_9183_9283 9183 9283 4.119063e+00
R_9283_9383 9283 9383 7.291124e+00
R_9383_9483 9383 9483 4.845355e+00
R_9483_9583 9483 9583 4.759547e+00
R_9583_9683 9583 9683 9.759157e+00
R_9683_9783 9683 9783 7.525392e+00
R_9783_9883 9783 9883 9.378968e+00
R_9883_9983 9883 9983 4.710692e+00
R_84_184 84 184 5.281446e-01
R_184_284 184 284 1.773311e+00
R_284_384 284 384 3.677484e+00
R_384_484 384 484 3.856605e+00
R_484_584 484 584 6.055608e+00
R_584_684 584 684 1.155231e+00
R_684_784 684 784 2.507985e+00
R_784_884 784 884 5.310607e+00
R_884_984 884 984 3.529436e+00
R_984_1084 984 1084 8.440749e-01
R_1084_1184 1084 1184 4.212766e+00
R_1184_1284 1184 1284 1.982106e+00
R_1284_1384 1284 1384 5.890604e+00
R_1384_1484 1384 1484 5.092536e+00
R_1484_1584 1484 1584 1.877053e+00
R_1584_1684 1584 1684 3.654338e+00
R_1684_1784 1684 1784 9.736961e+00
R_1784_1884 1784 1884 6.256476e+00
R_1884_1984 1884 1984 8.671247e+00
R_1984_2084 1984 2084 6.346394e+00
R_2084_2184 2084 2184 6.045679e+00
R_2184_2284 2184 2284 7.321719e+00
R_2284_2384 2284 2384 3.344804e+00
R_2384_2484 2384 2484 1.199724e+00
R_2484_2584 2484 2584 9.803696e+00
R_2584_2684 2584 2684 1.848082e+00
R_2684_2784 2684 2784 7.027838e+00
R_2784_2884 2784 2884 5.028241e+00
R_2884_2984 2884 2984 5.904751e+00
R_2984_3084 2984 3084 9.364640e+00
R_3084_3184 3084 3184 4.835280e+00
R_3184_3284 3184 3284 7.382301e+00
R_3284_3384 3284 3384 5.281426e+00
R_3384_3484 3384 3484 5.683382e+00
R_3484_3584 3484 3584 8.262276e+00
R_3584_3684 3584 3684 4.279351e+00
R_3684_3784 3684 3784 8.930538e+00
R_3784_3884 3784 3884 2.507527e+00
R_3884_3984 3884 3984 1.623679e-01
R_3984_4084 3984 4084 4.589687e+00
R_4084_4184 4084 4184 8.899657e+00
R_4184_4284 4184 4284 5.422751e+00
R_4284_4384 4284 4384 6.928935e+00
R_4384_4484 4384 4484 7.328352e+00
R_4484_4584 4484 4584 8.499886e+00
R_4584_4684 4584 4684 3.217989e+00
R_4684_4784 4684 4784 8.865000e+00
R_4784_4884 4784 4884 8.636090e+00
R_4884_4984 4884 4984 4.180207e+00
R_4984_5084 4984 5084 3.781404e-02
R_5084_5184 5084 5184 8.507036e+00
R_5184_5284 5184 5284 7.241225e+00
R_5284_5384 5284 5384 7.054969e+00
R_5384_5484 5384 5484 6.218516e+00
R_5484_5584 5484 5584 1.836570e+00
R_5584_5684 5584 5684 1.624508e+00
R_5684_5784 5684 5784 7.713252e-01
R_5784_5884 5784 5884 3.061953e+00
R_5884_5984 5884 5984 7.129680e-01
R_5984_6084 5984 6084 6.473159e+00
R_6084_6184 6084 6184 7.703274e+00
R_6184_6284 6184 6284 9.430693e+00
R_6284_6384 6284 6384 9.223512e+00
R_6384_6484 6384 6484 7.567812e+00
R_6484_6584 6484 6584 2.718548e+00
R_6584_6684 6584 6684 6.597987e+00
R_6684_6784 6684 6784 5.050177e+00
R_6784_6884 6784 6884 3.972645e+00
R_6884_6984 6884 6984 5.991534e+00
R_6984_7084 6984 7084 1.260143e+00
R_7084_7184 7084 7184 5.714171e+00
R_7184_7284 7184 7284 4.713690e+00
R_7284_7384 7284 7384 8.511673e-02
R_7384_7484 7384 7484 8.991381e+00
R_7484_7584 7484 7584 6.488877e+00
R_7584_7684 7584 7684 3.877152e+00
R_7684_7784 7684 7784 4.374907e+00
R_7784_7884 7784 7884 2.160196e+00
R_7884_7984 7884 7984 5.852589e+00
R_7984_8084 7984 8084 8.934774e+00
R_8084_8184 8084 8184 1.177281e+00
R_8184_8284 8184 8284 7.263659e+00
R_8284_8384 8284 8384 2.339810e-01
R_8384_8484 8384 8484 8.127921e+00
R_8484_8584 8484 8584 8.612102e+00
R_8584_8684 8584 8684 8.832155e+00
R_8684_8784 8684 8784 7.545814e+00
R_8784_8884 8784 8884 9.154809e+00
R_8884_8984 8884 8984 9.354453e+00
R_8984_9084 8984 9084 4.993040e+00
R_9084_9184 9084 9184 2.838191e+00
R_9184_9284 9184 9284 6.445392e+00
R_9284_9384 9284 9384 3.561887e+00
R_9384_9484 9384 9484 4.103325e+00
R_9484_9584 9484 9584 4.400286e+00
R_9584_9684 9584 9684 6.725678e+00
R_9684_9784 9684 9784 8.810766e+00
R_9784_9884 9784 9884 5.385277e+00
R_9884_9984 9884 9984 1.997744e+00
R_85_185 85 185 4.834191e+00
R_185_285 185 285 9.135452e+00
R_285_385 285 385 5.730807e+00
R_385_485 385 485 1.287297e+00
R_485_585 485 585 9.111129e+00
R_585_685 585 685 1.821969e+00
R_685_785 685 785 6.037449e+00
R_785_885 785 885 6.211514e+00
R_885_985 885 985 9.460138e+00
R_985_1085 985 1085 5.162650e+00
R_1085_1185 1085 1185 7.867708e+00
R_1185_1285 1185 1285 8.037006e+00
R_1285_1385 1285 1385 1.033908e-01
R_1385_1485 1385 1485 2.864191e+00
R_1485_1585 1485 1585 5.096903e-01
R_1585_1685 1585 1685 2.192652e+00
R_1685_1785 1685 1785 8.815819e+00
R_1785_1885 1785 1885 5.970000e+00
R_1885_1985 1885 1985 6.116823e+00
R_1985_2085 1985 2085 3.291592e+00
R_2085_2185 2085 2185 3.912463e+00
R_2185_2285 2185 2285 3.563642e+00
R_2285_2385 2285 2385 4.144441e+00
R_2385_2485 2385 2485 8.188813e+00
R_2485_2585 2485 2585 8.144464e-01
R_2585_2685 2585 2685 5.070214e+00
R_2685_2785 2685 2785 3.565570e+00
R_2785_2885 2785 2885 6.137433e+00
R_2885_2985 2885 2985 6.786870e+00
R_2985_3085 2985 3085 1.377958e+00
R_3085_3185 3085 3185 8.259680e+00
R_3185_3285 3185 3285 2.796843e+00
R_3285_3385 3285 3385 8.999547e+00
R_3385_3485 3385 3485 7.675661e+00
R_3485_3585 3485 3585 4.325230e+00
R_3585_3685 3585 3685 6.087078e+00
R_3685_3785 3685 3785 7.066156e+00
R_3785_3885 3785 3885 1.114079e+00
R_3885_3985 3885 3985 6.717819e+00
R_3985_4085 3985 4085 1.634209e+00
R_4085_4185 4085 4185 3.297675e+00
R_4185_4285 4185 4285 9.134304e+00
R_4285_4385 4285 4385 6.674887e+00
R_4385_4485 4385 4485 4.500546e+00
R_4485_4585 4485 4585 8.891986e+00
R_4585_4685 4585 4685 3.493213e+00
R_4685_4785 4685 4785 3.444743e+00
R_4785_4885 4785 4885 9.455818e+00
R_4885_4985 4885 4985 2.778331e+00
R_4985_5085 4985 5085 2.502830e+00
R_5085_5185 5085 5185 1.313739e-02
R_5185_5285 5185 5285 5.319062e+00
R_5285_5385 5285 5385 3.690223e+00
R_5385_5485 5385 5485 4.814765e+00
R_5485_5585 5485 5585 4.809106e+00
R_5585_5685 5585 5685 3.160302e-01
R_5685_5785 5685 5785 8.515070e+00
R_5785_5885 5785 5885 6.213396e-02
R_5885_5985 5885 5985 6.214355e+00
R_5985_6085 5985 6085 3.105833e+00
R_6085_6185 6085 6185 8.588404e-02
R_6185_6285 6185 6285 6.789983e+00
R_6285_6385 6285 6385 6.379199e+00
R_6385_6485 6385 6485 4.963419e+00
R_6485_6585 6485 6585 9.437640e-01
R_6585_6685 6585 6685 7.874264e+00
R_6685_6785 6685 6785 8.942837e+00
R_6785_6885 6785 6885 5.395267e+00
R_6885_6985 6885 6985 2.287384e+00
R_6985_7085 6985 7085 4.791760e+00
R_7085_7185 7085 7185 7.135996e+00
R_7185_7285 7185 7285 3.827984e+00
R_7285_7385 7285 7385 3.692801e+00
R_7385_7485 7385 7485 5.232471e+00
R_7485_7585 7485 7585 1.111140e+00
R_7585_7685 7585 7685 6.008684e+00
R_7685_7785 7685 7785 2.407512e+00
R_7785_7885 7785 7885 9.838914e-01
R_7885_7985 7885 7985 8.627669e+00
R_7985_8085 7985 8085 4.721711e+00
R_8085_8185 8085 8185 4.258378e+00
R_8185_8285 8185 8285 5.553053e+00
R_8285_8385 8285 8385 3.987121e+00
R_8385_8485 8385 8485 5.964372e+00
R_8485_8585 8485 8585 9.994185e+00
R_8585_8685 8585 8685 2.502952e+00
R_8685_8785 8685 8785 9.641951e+00
R_8785_8885 8785 8885 6.458935e+00
R_8885_8985 8885 8985 7.204169e+00
R_8985_9085 8985 9085 4.840149e+00
R_9085_9185 9085 9185 3.965542e+00
R_9185_9285 9185 9285 6.467587e+00
R_9285_9385 9285 9385 2.725907e+00
R_9385_9485 9385 9485 7.792408e+00
R_9485_9585 9485 9585 5.332654e+00
R_9585_9685 9585 9685 5.367809e+00
R_9685_9785 9685 9785 4.347641e+00
R_9785_9885 9785 9885 1.466571e+00
R_9885_9985 9885 9985 4.287183e+00
R_86_186 86 186 1.695190e+00
R_186_286 186 286 5.453257e+00
R_286_386 286 386 2.518569e+00
R_386_486 386 486 4.075065e+00
R_486_586 486 586 5.309052e-01
R_586_686 586 686 4.563152e+00
R_686_786 686 786 4.899351e+00
R_786_886 786 886 8.417449e+00
R_886_986 886 986 6.571817e+00
R_986_1086 986 1086 7.528232e+00
R_1086_1186 1086 1186 4.451675e+00
R_1186_1286 1186 1286 9.747412e+00
R_1286_1386 1286 1386 9.995517e+00
R_1386_1486 1386 1486 9.089298e+00
R_1486_1586 1486 1586 2.939417e+00
R_1586_1686 1586 1686 3.324356e+00
R_1686_1786 1686 1786 6.558823e+00
R_1786_1886 1786 1886 5.358053e+00
R_1886_1986 1886 1986 5.101559e+00
R_1986_2086 1986 2086 1.306426e+00
R_2086_2186 2086 2186 8.197834e+00
R_2186_2286 2186 2286 6.475327e+00
R_2286_2386 2286 2386 8.738862e+00
R_2386_2486 2386 2486 9.575052e+00
R_2486_2586 2486 2586 5.296838e+00
R_2586_2686 2586 2686 4.398348e+00
R_2686_2786 2686 2786 6.075754e+00
R_2786_2886 2786 2886 2.858094e+00
R_2886_2986 2886 2986 1.352462e+00
R_2986_3086 2986 3086 5.833018e+00
R_3086_3186 3086 3186 9.040840e+00
R_3186_3286 3186 3286 7.033514e+00
R_3286_3386 3286 3386 3.716647e+00
R_3386_3486 3386 3486 4.532195e+00
R_3486_3586 3486 3586 6.514569e+00
R_3586_3686 3586 3686 4.187308e+00
R_3686_3786 3686 3786 8.895215e+00
R_3786_3886 3786 3886 4.000633e+00
R_3886_3986 3886 3986 5.606155e+00
R_3986_4086 3986 4086 8.665738e+00
R_4086_4186 4086 4186 9.158652e+00
R_4186_4286 4186 4286 1.221998e+00
R_4286_4386 4286 4386 6.610030e+00
R_4386_4486 4386 4486 5.164208e+00
R_4486_4586 4486 4586 2.012464e+00
R_4586_4686 4586 4686 1.159802e+00
R_4686_4786 4686 4786 8.578069e+00
R_4786_4886 4786 4886 8.127211e+00
R_4886_4986 4886 4986 8.477175e+00
R_4986_5086 4986 5086 3.972539e+00
R_5086_5186 5086 5186 3.904347e+00
R_5186_5286 5186 5286 8.661345e+00
R_5286_5386 5286 5386 2.682284e+00
R_5386_5486 5386 5486 9.322168e+00
R_5486_5586 5486 5586 8.915337e+00
R_5586_5686 5586 5686 6.405757e+00
R_5686_5786 5686 5786 8.123542e+00
R_5786_5886 5786 5886 1.740967e+00
R_5886_5986 5886 5986 5.972438e+00
R_5986_6086 5986 6086 7.579265e+00
R_6086_6186 6086 6186 4.434366e+00
R_6186_6286 6186 6286 1.679084e-01
R_6286_6386 6286 6386 7.171237e+00
R_6386_6486 6386 6486 3.979362e+00
R_6486_6586 6486 6586 6.368732e+00
R_6586_6686 6586 6686 5.398657e+00
R_6686_6786 6686 6786 4.481760e+00
R_6786_6886 6786 6886 4.924113e+00
R_6886_6986 6886 6986 3.440252e+00
R_6986_7086 6986 7086 1.135617e+00
R_7086_7186 7086 7186 8.918970e+00
R_7186_7286 7186 7286 5.770871e-01
R_7286_7386 7286 7386 4.675599e+00
R_7386_7486 7386 7486 2.000935e+00
R_7486_7586 7486 7586 8.212017e+00
R_7586_7686 7586 7686 4.321113e+00
R_7686_7786 7686 7786 7.192357e+00
R_7786_7886 7786 7886 8.874830e+00
R_7886_7986 7886 7986 5.621381e+00
R_7986_8086 7986 8086 9.103320e-01
R_8086_8186 8086 8186 2.171969e+00
R_8186_8286 8186 8286 2.399425e+00
R_8286_8386 8286 8386 3.232977e+00
R_8386_8486 8386 8486 2.865876e+00
R_8486_8586 8486 8586 1.149990e+00
R_8586_8686 8586 8686 3.070971e+00
R_8686_8786 8686 8786 4.204236e+00
R_8786_8886 8786 8886 1.003281e+00
R_8886_8986 8886 8986 4.586147e+00
R_8986_9086 8986 9086 9.870898e+00
R_9086_9186 9086 9186 1.723289e+00
R_9186_9286 9186 9286 6.973332e+00
R_9286_9386 9286 9386 2.685070e+00
R_9386_9486 9386 9486 3.143767e-01
R_9486_9586 9486 9586 6.647054e+00
R_9586_9686 9586 9686 5.827537e+00
R_9686_9786 9686 9786 3.817468e+00
R_9786_9886 9786 9886 7.111245e+00
R_9886_9986 9886 9986 3.589367e+00
R_87_187 87 187 5.621541e+00
R_187_287 187 287 6.743924e+00
R_287_387 287 387 3.294913e+00
R_387_487 387 487 7.556924e+00
R_487_587 487 587 6.565136e-01
R_587_687 587 687 2.426150e-01
R_687_787 687 787 5.285655e+00
R_787_887 787 887 5.451590e+00
R_887_987 887 987 7.384261e+00
R_987_1087 987 1087 3.087621e+00
R_1087_1187 1087 1187 8.142209e+00
R_1187_1287 1187 1287 2.186450e+00
R_1287_1387 1287 1387 5.445501e+00
R_1387_1487 1387 1487 8.934040e+00
R_1487_1587 1487 1587 4.724685e+00
R_1587_1687 1587 1687 3.128476e-02
R_1687_1787 1687 1787 3.086854e+00
R_1787_1887 1787 1887 9.542185e+00
R_1887_1987 1887 1987 6.890433e+00
R_1987_2087 1987 2087 1.115706e+00
R_2087_2187 2087 2187 2.505818e+00
R_2187_2287 2187 2287 9.721499e+00
R_2287_2387 2287 2387 7.719227e+00
R_2387_2487 2387 2487 1.263628e+00
R_2487_2587 2487 2587 9.178713e+00
R_2587_2687 2587 2687 5.058691e+00
R_2687_2787 2687 2787 3.474556e+00
R_2787_2887 2787 2887 5.534068e+00
R_2887_2987 2887 2987 1.164668e+00
R_2987_3087 2987 3087 1.508708e+00
R_3087_3187 3087 3187 4.088818e+00
R_3187_3287 3187 3287 6.054537e+00
R_3287_3387 3287 3387 2.235974e+00
R_3387_3487 3387 3487 4.879607e+00
R_3487_3587 3487 3587 8.880900e+00
R_3587_3687 3587 3687 7.380160e+00
R_3687_3787 3687 3787 6.834898e+00
R_3787_3887 3787 3887 2.097204e-01
R_3887_3987 3887 3987 7.001224e+00
R_3987_4087 3987 4087 8.618444e+00
R_4087_4187 4087 4187 9.884917e+00
R_4187_4287 4187 4287 2.694869e+00
R_4287_4387 4287 4387 9.310389e+00
R_4387_4487 4387 4487 8.789779e+00
R_4487_4587 4487 4587 2.205314e+00
R_4587_4687 4587 4687 2.532836e+00
R_4687_4787 4687 4787 2.014063e+00
R_4787_4887 4787 4887 2.583642e+00
R_4887_4987 4887 4987 6.485599e+00
R_4987_5087 4987 5087 7.077811e+00
R_5087_5187 5087 5187 1.368916e+00
R_5187_5287 5187 5287 9.668178e-01
R_5287_5387 5287 5387 5.557226e-01
R_5387_5487 5387 5487 8.242928e+00
R_5487_5587 5487 5587 6.514510e+00
R_5587_5687 5587 5687 8.385783e-01
R_5687_5787 5687 5787 8.396976e+00
R_5787_5887 5787 5887 5.033015e+00
R_5887_5987 5887 5987 5.272592e+00
R_5987_6087 5987 6087 3.984888e+00
R_6087_6187 6087 6187 9.744154e+00
R_6187_6287 6187 6287 5.369216e+00
R_6287_6387 6287 6387 9.415118e+00
R_6387_6487 6387 6487 1.534191e+00
R_6487_6587 6487 6587 9.154699e+00
R_6587_6687 6587 6687 3.955991e+00
R_6687_6787 6687 6787 5.692684e+00
R_6787_6887 6787 6887 4.956373e+00
R_6887_6987 6887 6987 6.592880e+00
R_6987_7087 6987 7087 6.593734e-01
R_7087_7187 7087 7187 7.882903e-01
R_7187_7287 7187 7287 6.114178e+00
R_7287_7387 7287 7387 8.241743e+00
R_7387_7487 7387 7487 2.755870e-01
R_7487_7587 7487 7587 7.587235e-01
R_7587_7687 7587 7687 3.741212e+00
R_7687_7787 7687 7787 6.143394e+00
R_7787_7887 7787 7887 2.827644e+00
R_7887_7987 7887 7987 4.061091e+00
R_7987_8087 7987 8087 9.601329e+00
R_8087_8187 8087 8187 1.856841e+00
R_8187_8287 8187 8287 7.692111e+00
R_8287_8387 8287 8387 7.471796e+00
R_8387_8487 8387 8487 7.067319e+00
R_8487_8587 8487 8587 9.704751e+00
R_8587_8687 8587 8687 2.653354e+00
R_8687_8787 8687 8787 1.070860e+00
R_8787_8887 8787 8887 1.279539e+00
R_8887_8987 8887 8987 8.828379e+00
R_8987_9087 8987 9087 3.557151e+00
R_9087_9187 9087 9187 3.390061e+00
R_9187_9287 9187 9287 4.229890e+00
R_9287_9387 9287 9387 7.964134e+00
R_9387_9487 9387 9487 6.012728e+00
R_9487_9587 9487 9587 5.767044e+00
R_9587_9687 9587 9687 2.312668e+00
R_9687_9787 9687 9787 4.807059e+00
R_9787_9887 9787 9887 7.226451e+00
R_9887_9987 9887 9987 7.223535e+00
R_88_188 88 188 4.668272e+00
R_188_288 188 288 8.274400e+00
R_288_388 288 388 9.814237e+00
R_388_488 388 488 1.471506e+00
R_488_588 488 588 7.979583e+00
R_588_688 588 688 6.176515e+00
R_688_788 688 788 4.421422e+00
R_788_888 788 888 4.255727e+00
R_888_988 888 988 9.946724e+00
R_988_1088 988 1088 7.635499e+00
R_1088_1188 1088 1188 1.924697e+00
R_1188_1288 1188 1288 9.021912e+00
R_1288_1388 1288 1388 3.350174e+00
R_1388_1488 1388 1488 5.210608e+00
R_1488_1588 1488 1588 4.435379e+00
R_1588_1688 1588 1688 5.324868e+00
R_1688_1788 1688 1788 7.050026e+00
R_1788_1888 1788 1888 4.929667e+00
R_1888_1988 1888 1988 1.536694e+00
R_1988_2088 1988 2088 8.518323e+00
R_2088_2188 2088 2188 2.990621e+00
R_2188_2288 2188 2288 5.770261e+00
R_2288_2388 2288 2388 8.580462e+00
R_2388_2488 2388 2488 2.660443e+00
R_2488_2588 2488 2588 8.169936e+00
R_2588_2688 2588 2688 5.391236e+00
R_2688_2788 2688 2788 2.582934e-02
R_2788_2888 2788 2888 2.678641e+00
R_2888_2988 2888 2988 6.330379e+00
R_2988_3088 2988 3088 3.387040e+00
R_3088_3188 3088 3188 5.744327e-01
R_3188_3288 3188 3288 9.037621e-01
R_3288_3388 3288 3388 6.015686e+00
R_3388_3488 3388 3488 7.851030e-01
R_3488_3588 3488 3588 4.137373e-01
R_3588_3688 3588 3688 4.388703e+00
R_3688_3788 3688 3788 9.012234e+00
R_3788_3888 3788 3888 4.760491e+00
R_3888_3988 3888 3988 8.881081e+00
R_3988_4088 3988 4088 9.322736e+00
R_4088_4188 4088 4188 1.612334e+00
R_4188_4288 4188 4288 3.288611e+00
R_4288_4388 4288 4388 4.557609e+00
R_4388_4488 4388 4488 6.160320e+00
R_4488_4588 4488 4588 9.019503e+00
R_4588_4688 4588 4688 7.409297e-01
R_4688_4788 4688 4788 4.139668e+00
R_4788_4888 4788 4888 3.343864e+00
R_4888_4988 4888 4988 8.748724e+00
R_4988_5088 4988 5088 5.171038e+00
R_5088_5188 5088 5188 6.986018e-01
R_5188_5288 5188 5288 2.799302e+00
R_5288_5388 5288 5388 7.664546e+00
R_5388_5488 5388 5488 7.469959e+00
R_5488_5588 5488 5588 9.610374e+00
R_5588_5688 5588 5688 1.646665e+00
R_5688_5788 5688 5788 3.463498e+00
R_5788_5888 5788 5888 6.633509e+00
R_5888_5988 5888 5988 4.853004e+00
R_5988_6088 5988 6088 5.041412e+00
R_6088_6188 6088 6188 6.639102e+00
R_6188_6288 6188 6288 4.274874e+00
R_6288_6388 6288 6388 4.846823e+00
R_6388_6488 6388 6488 8.245524e+00
R_6488_6588 6488 6588 3.075761e+00
R_6588_6688 6588 6688 2.959234e+00
R_6688_6788 6688 6788 8.103821e+00
R_6788_6888 6788 6888 5.444770e+00
R_6888_6988 6888 6988 4.573137e-02
R_6988_7088 6988 7088 2.442471e+00
R_7088_7188 7088 7188 4.579313e+00
R_7188_7288 7188 7288 9.145202e+00
R_7288_7388 7288 7388 1.614441e+00
R_7388_7488 7388 7488 2.665226e-01
R_7488_7588 7488 7588 1.360609e-01
R_7588_7688 7588 7688 6.011398e+00
R_7688_7788 7688 7788 7.612674e+00
R_7788_7888 7788 7888 8.002375e+00
R_7888_7988 7888 7988 7.128860e+00
R_7988_8088 7988 8088 6.287618e+00
R_8088_8188 8088 8188 7.796618e+00
R_8188_8288 8188 8288 8.809381e+00
R_8288_8388 8288 8388 4.157328e+00
R_8388_8488 8388 8488 6.467339e+00
R_8488_8588 8488 8588 4.415578e+00
R_8588_8688 8588 8688 6.776282e+00
R_8688_8788 8688 8788 8.905530e+00
R_8788_8888 8788 8888 8.633461e+00
R_8888_8988 8888 8988 4.753813e+00
R_8988_9088 8988 9088 9.222498e+00
R_9088_9188 9088 9188 9.208637e+00
R_9188_9288 9188 9288 2.859831e+00
R_9288_9388 9288 9388 2.285029e+00
R_9388_9488 9388 9488 8.622554e+00
R_9488_9588 9488 9588 8.762686e-01
R_9588_9688 9588 9688 4.858222e+00
R_9688_9788 9688 9788 9.507320e+00
R_9788_9888 9788 9888 6.395561e+00
R_9888_9988 9888 9988 3.504075e+00
R_89_189 89 189 8.448051e+00
R_189_289 189 289 1.590881e+00
R_289_389 289 389 4.471918e+00
R_389_489 389 489 6.636587e+00
R_489_589 489 589 2.932575e+00
R_589_689 589 689 8.193402e+00
R_689_789 689 789 6.879469e+00
R_789_889 789 889 2.331239e+00
R_889_989 889 989 1.327536e+00
R_989_1089 989 1089 9.781261e+00
R_1089_1189 1089 1189 7.975845e+00
R_1189_1289 1189 1289 8.076876e+00
R_1289_1389 1289 1389 8.876444e+00
R_1389_1489 1389 1489 9.457894e+00
R_1489_1589 1489 1589 5.082134e+00
R_1589_1689 1589 1689 9.390328e+00
R_1689_1789 1689 1789 6.279312e-01
R_1789_1889 1789 1889 5.567634e+00
R_1889_1989 1889 1989 5.380045e-01
R_1989_2089 1989 2089 4.683675e-01
R_2089_2189 2089 2189 2.328772e-01
R_2189_2289 2189 2289 4.602895e+00
R_2289_2389 2289 2389 4.687897e+00
R_2389_2489 2389 2489 6.270206e+00
R_2489_2589 2489 2589 8.937622e+00
R_2589_2689 2589 2689 3.954713e+00
R_2689_2789 2689 2789 6.190466e+00
R_2789_2889 2789 2889 4.190537e+00
R_2889_2989 2889 2989 9.509960e+00
R_2989_3089 2989 3089 2.066580e+00
R_3089_3189 3089 3189 8.063240e+00
R_3189_3289 3189 3289 6.710954e+00
R_3289_3389 3289 3389 7.786174e+00
R_3389_3489 3389 3489 9.334305e+00
R_3489_3589 3489 3589 6.949560e+00
R_3589_3689 3589 3689 3.390001e+00
R_3689_3789 3689 3789 7.120294e+00
R_3789_3889 3789 3889 7.562981e+00
R_3889_3989 3889 3989 1.915386e-01
R_3989_4089 3989 4089 9.431278e+00
R_4089_4189 4089 4189 6.686820e+00
R_4189_4289 4189 4289 5.136382e+00
R_4289_4389 4289 4389 5.860768e+00
R_4389_4489 4389 4489 6.026071e+00
R_4489_4589 4489 4589 6.942594e+00
R_4589_4689 4589 4689 1.302442e+00
R_4689_4789 4689 4789 8.489540e+00
R_4789_4889 4789 4889 6.325675e+00
R_4889_4989 4889 4989 8.839475e+00
R_4989_5089 4989 5089 5.325191e+00
R_5089_5189 5089 5189 7.278236e+00
R_5189_5289 5189 5289 7.166931e+00
R_5289_5389 5289 5389 8.044002e+00
R_5389_5489 5389 5489 8.791571e+00
R_5489_5589 5489 5589 8.845655e+00
R_5589_5689 5589 5689 7.103244e+00
R_5689_5789 5689 5789 4.424188e+00
R_5789_5889 5789 5889 7.742642e+00
R_5889_5989 5889 5989 8.211547e+00
R_5989_6089 5989 6089 9.276386e+00
R_6089_6189 6089 6189 7.523148e+00
R_6189_6289 6189 6289 6.121817e+00
R_6289_6389 6289 6389 6.563974e+00
R_6389_6489 6389 6489 4.180033e+00
R_6489_6589 6489 6589 1.750777e+00
R_6589_6689 6589 6689 8.886982e+00
R_6689_6789 6689 6789 4.968237e+00
R_6789_6889 6789 6889 2.869129e+00
R_6889_6989 6889 6989 5.912582e+00
R_6989_7089 6989 7089 3.294602e+00
R_7089_7189 7089 7189 3.704521e-01
R_7189_7289 7189 7289 7.613574e+00
R_7289_7389 7289 7389 7.417859e+00
R_7389_7489 7389 7489 7.248623e+00
R_7489_7589 7489 7589 1.920610e+00
R_7589_7689 7589 7689 4.533971e+00
R_7689_7789 7689 7789 9.202396e+00
R_7789_7889 7789 7889 2.314700e+00
R_7889_7989 7889 7989 3.530046e+00
R_7989_8089 7989 8089 4.964559e+00
R_8089_8189 8089 8189 9.036549e+00
R_8189_8289 8189 8289 5.629400e+00
R_8289_8389 8289 8389 9.380460e+00
R_8389_8489 8389 8489 8.002941e+00
R_8489_8589 8489 8589 5.338634e-02
R_8589_8689 8589 8689 8.249578e+00
R_8689_8789 8689 8789 3.160491e+00
R_8789_8889 8789 8889 9.744874e+00
R_8889_8989 8889 8989 7.723037e+00
R_8989_9089 8989 9089 4.284420e+00
R_9089_9189 9089 9189 1.520214e+00
R_9189_9289 9189 9289 1.913469e+00
R_9289_9389 9289 9389 6.424239e+00
R_9389_9489 9389 9489 7.145785e+00
R_9489_9589 9489 9589 4.583501e-01
R_9589_9689 9589 9689 8.752574e+00
R_9689_9789 9689 9789 5.043989e-01
R_9789_9889 9789 9889 6.411333e+00
R_9889_9989 9889 9989 1.917625e+00
R_90_190 90 190 5.472364e+00
R_190_290 190 290 4.852735e+00
R_290_390 290 390 4.030779e+00
R_390_490 390 490 9.929072e+00
R_490_590 490 590 6.660551e-01
R_590_690 590 690 3.546855e+00
R_690_790 690 790 4.601512e+00
R_790_890 790 890 6.460728e+00
R_890_990 890 990 7.878710e+00
R_990_1090 990 1090 2.554526e+00
R_1090_1190 1090 1190 8.786491e+00
R_1190_1290 1190 1290 4.479365e+00
R_1290_1390 1290 1390 3.163216e+00
R_1390_1490 1390 1490 1.981598e+00
R_1490_1590 1490 1590 2.038194e+00
R_1590_1690 1590 1690 4.677332e+00
R_1690_1790 1690 1790 4.920159e+00
R_1790_1890 1790 1890 3.958338e-01
R_1890_1990 1890 1990 1.052741e+00
R_1990_2090 1990 2090 5.180959e+00
R_2090_2190 2090 2190 3.479741e-01
R_2190_2290 2190 2290 9.493295e-02
R_2290_2390 2290 2390 4.822704e+00
R_2390_2490 2390 2490 2.632646e+00
R_2490_2590 2490 2590 5.809134e+00
R_2590_2690 2590 2690 3.957772e+00
R_2690_2790 2690 2790 4.563413e+00
R_2790_2890 2790 2890 3.428577e-01
R_2890_2990 2890 2990 4.029333e-01
R_2990_3090 2990 3090 4.247615e+00
R_3090_3190 3090 3190 4.377186e+00
R_3190_3290 3190 3290 6.347882e+00
R_3290_3390 3290 3390 6.960902e+00
R_3390_3490 3390 3490 2.660233e+00
R_3490_3590 3490 3590 7.480027e+00
R_3590_3690 3590 3690 1.672157e+00
R_3690_3790 3690 3790 6.137167e+00
R_3790_3890 3790 3890 9.976881e+00
R_3890_3990 3890 3990 4.912186e+00
R_3990_4090 3990 4090 7.576786e+00
R_4090_4190 4090 4190 7.173192e+00
R_4190_4290 4190 4290 9.988817e+00
R_4290_4390 4290 4390 5.079758e+00
R_4390_4490 4390 4490 3.919131e+00
R_4490_4590 4490 4590 2.299801e+00
R_4590_4690 4590 4690 8.951693e+00
R_4690_4790 4690 4790 4.490589e+00
R_4790_4890 4790 4890 7.379738e+00
R_4890_4990 4890 4990 8.018087e+00
R_4990_5090 4990 5090 4.501718e+00
R_5090_5190 5090 5190 7.730653e+00
R_5190_5290 5190 5290 6.612109e+00
R_5290_5390 5290 5390 8.391791e+00
R_5390_5490 5390 5490 5.170896e+00
R_5490_5590 5490 5590 9.625201e+00
R_5590_5690 5590 5690 5.008930e+00
R_5690_5790 5690 5790 6.346898e+00
R_5790_5890 5790 5890 7.534182e+00
R_5890_5990 5890 5990 5.080096e+00
R_5990_6090 5990 6090 3.279931e+00
R_6090_6190 6090 6190 6.735671e+00
R_6190_6290 6190 6290 4.947218e+00
R_6290_6390 6290 6390 3.802450e+00
R_6390_6490 6390 6490 1.979453e+00
R_6490_6590 6490 6590 4.212551e+00
R_6590_6690 6590 6690 8.596588e+00
R_6690_6790 6690 6790 4.909686e+00
R_6790_6890 6790 6890 1.733539e+00
R_6890_6990 6890 6990 2.297783e+00
R_6990_7090 6990 7090 2.878899e+00
R_7090_7190 7090 7190 5.257220e+00
R_7190_7290 7190 7290 4.341986e+00
R_7290_7390 7290 7390 5.193527e+00
R_7390_7490 7390 7490 3.179697e+00
R_7490_7590 7490 7590 1.301593e+00
R_7590_7690 7590 7690 5.794558e+00
R_7690_7790 7690 7790 1.477096e+00
R_7790_7890 7790 7890 3.537490e+00
R_7890_7990 7890 7990 1.310864e+00
R_7990_8090 7990 8090 8.071402e-01
R_8090_8190 8090 8190 2.388159e+00
R_8190_8290 8190 8290 3.085738e+00
R_8290_8390 8290 8390 4.168500e+00
R_8390_8490 8390 8490 2.961156e+00
R_8490_8590 8490 8590 2.849137e+00
R_8590_8690 8590 8690 6.002842e+00
R_8690_8790 8690 8790 5.349532e+00
R_8790_8890 8790 8890 4.182639e+00
R_8890_8990 8890 8990 4.204292e-01
R_8990_9090 8990 9090 5.959603e+00
R_9090_9190 9090 9190 2.749122e+00
R_9190_9290 9190 9290 8.008741e+00
R_9290_9390 9290 9390 8.507167e+00
R_9390_9490 9390 9490 3.122835e+00
R_9490_9590 9490 9590 4.833806e+00
R_9590_9690 9590 9690 6.101354e+00
R_9690_9790 9690 9790 3.671032e+00
R_9790_9890 9790 9890 4.182507e+00
R_9890_9990 9890 9990 5.316981e+00
R_91_191 91 191 8.121768e+00
R_191_291 191 291 4.351043e+00
R_291_391 291 391 6.886014e+00
R_391_491 391 491 2.662319e+00
R_491_591 491 591 9.577101e+00
R_591_691 591 691 9.423922e+00
R_691_791 691 791 8.068721e+00
R_791_891 791 891 6.026158e+00
R_891_991 891 991 4.603950e+00
R_991_1091 991 1091 9.973705e+00
R_1091_1191 1091 1191 5.750799e+00
R_1191_1291 1191 1291 8.697737e+00
R_1291_1391 1291 1391 5.711649e+00
R_1391_1491 1391 1491 5.558142e+00
R_1491_1591 1491 1591 8.130128e+00
R_1591_1691 1591 1691 9.098754e+00
R_1691_1791 1691 1791 9.957856e+00
R_1791_1891 1791 1891 5.304612e+00
R_1891_1991 1891 1991 2.461212e+00
R_1991_2091 1991 2091 3.147467e+00
R_2091_2191 2091 2191 8.369705e+00
R_2191_2291 2191 2291 3.338472e+00
R_2291_2391 2291 2391 4.099985e+00
R_2391_2491 2391 2491 9.917068e+00
R_2491_2591 2491 2591 1.662452e+00
R_2591_2691 2591 2691 3.425739e-01
R_2691_2791 2691 2791 2.562802e+00
R_2791_2891 2791 2891 7.817656e+00
R_2891_2991 2891 2991 9.393806e+00
R_2991_3091 2991 3091 9.095371e+00
R_3091_3191 3091 3191 4.961236e+00
R_3191_3291 3191 3291 4.128417e+00
R_3291_3391 3291 3391 1.605515e+00
R_3391_3491 3391 3491 8.974604e+00
R_3491_3591 3491 3591 4.752982e+00
R_3591_3691 3591 3691 7.960909e+00
R_3691_3791 3691 3791 9.398432e+00
R_3791_3891 3791 3891 5.225712e+00
R_3891_3991 3891 3991 3.566626e+00
R_3991_4091 3991 4091 5.313971e+00
R_4091_4191 4091 4191 2.370524e+00
R_4191_4291 4191 4291 9.057517e+00
R_4291_4391 4291 4391 6.459956e+00
R_4391_4491 4391 4491 9.379398e+00
R_4491_4591 4491 4591 5.197957e+00
R_4591_4691 4591 4691 2.977444e+00
R_4691_4791 4691 4791 9.392577e+00
R_4791_4891 4791 4891 3.039333e+00
R_4891_4991 4891 4991 3.882186e+00
R_4991_5091 4991 5091 1.014764e+00
R_5091_5191 5091 5191 7.287194e+00
R_5191_5291 5191 5291 1.824496e+00
R_5291_5391 5291 5391 5.709411e+00
R_5391_5491 5391 5491 2.721333e+00
R_5491_5591 5491 5591 9.975915e+00
R_5591_5691 5591 5691 4.280849e+00
R_5691_5791 5691 5791 9.062190e+00
R_5791_5891 5791 5891 9.474859e+00
R_5891_5991 5891 5991 6.178791e+00
R_5991_6091 5991 6091 3.457222e+00
R_6091_6191 6091 6191 8.266180e+00
R_6191_6291 6191 6291 4.294986e+00
R_6291_6391 6291 6391 1.432036e+00
R_6391_6491 6391 6491 4.056122e+00
R_6491_6591 6491 6591 6.712975e-01
R_6591_6691 6591 6691 1.660776e+00
R_6691_6791 6691 6791 3.358572e+00
R_6791_6891 6791 6891 1.677123e+00
R_6891_6991 6891 6991 2.695999e+00
R_6991_7091 6991 7091 5.706295e+00
R_7091_7191 7091 7191 7.221203e+00
R_7191_7291 7191 7291 8.202989e-01
R_7291_7391 7291 7391 2.726888e+00
R_7391_7491 7391 7491 1.731521e+00
R_7491_7591 7491 7591 9.229670e+00
R_7591_7691 7591 7691 5.207037e+00
R_7691_7791 7691 7791 9.278532e+00
R_7791_7891 7791 7891 7.540548e+00
R_7891_7991 7891 7991 5.309135e-01
R_7991_8091 7991 8091 9.549816e-01
R_8091_8191 8091 8191 8.270334e+00
R_8191_8291 8191 8291 3.831525e+00
R_8291_8391 8291 8391 7.318632e+00
R_8391_8491 8391 8491 6.431582e+00
R_8491_8591 8491 8591 2.813535e-01
R_8591_8691 8591 8691 4.679729e+00
R_8691_8791 8691 8791 6.017972e+00
R_8791_8891 8791 8891 4.520995e+00
R_8891_8991 8891 8991 4.753618e+00
R_8991_9091 8991 9091 5.111891e+00
R_9091_9191 9091 9191 4.441289e+00
R_9191_9291 9191 9291 8.316428e+00
R_9291_9391 9291 9391 8.479647e+00
R_9391_9491 9391 9491 1.048725e+00
R_9491_9591 9491 9591 4.774381e+00
R_9591_9691 9591 9691 9.373826e+00
R_9691_9791 9691 9791 1.335159e+00
R_9791_9891 9791 9891 2.490225e+00
R_9891_9991 9891 9991 1.077923e+00
R_92_192 92 192 9.780915e+00
R_192_292 192 292 6.771687e-01
R_292_392 292 392 7.166426e+00
R_392_492 392 492 1.164606e+00
R_492_592 492 592 5.335347e+00
R_592_692 592 692 5.908171e+00
R_692_792 692 792 3.146982e+00
R_792_892 792 892 2.383281e+00
R_892_992 892 992 9.597561e-01
R_992_1092 992 1092 6.128878e-02
R_1092_1192 1092 1192 6.524391e+00
R_1192_1292 1192 1292 5.998086e+00
R_1292_1392 1292 1392 1.272442e+00
R_1392_1492 1392 1492 7.137312e+00
R_1492_1592 1492 1592 3.145559e+00
R_1592_1692 1592 1692 9.550738e+00
R_1692_1792 1692 1792 8.918978e+00
R_1792_1892 1792 1892 7.940301e+00
R_1892_1992 1892 1992 9.290916e+00
R_1992_2092 1992 2092 6.943823e-01
R_2092_2192 2092 2192 6.137890e+00
R_2192_2292 2192 2292 2.067014e+00
R_2292_2392 2292 2392 2.528226e+00
R_2392_2492 2392 2492 8.055318e+00
R_2492_2592 2492 2592 3.254701e-01
R_2592_2692 2592 2692 1.001087e+00
R_2692_2792 2692 2792 9.758756e+00
R_2792_2892 2792 2892 5.312427e+00
R_2892_2992 2892 2992 3.346266e+00
R_2992_3092 2992 3092 6.335921e+00
R_3092_3192 3092 3192 6.718192e+00
R_3192_3292 3192 3292 9.938067e+00
R_3292_3392 3292 3392 3.400622e+00
R_3392_3492 3392 3492 2.485203e+00
R_3492_3592 3492 3592 8.503581e+00
R_3592_3692 3592 3692 3.571415e+00
R_3692_3792 3692 3792 4.256183e+00
R_3792_3892 3792 3892 8.194486e-01
R_3892_3992 3892 3992 1.564205e-01
R_3992_4092 3992 4092 4.548850e+00
R_4092_4192 4092 4192 1.691480e+00
R_4192_4292 4192 4292 1.261030e+00
R_4292_4392 4292 4392 8.829090e+00
R_4392_4492 4392 4492 7.091768e-01
R_4492_4592 4492 4592 6.031747e+00
R_4592_4692 4592 4692 7.961093e+00
R_4692_4792 4692 4792 5.027877e+00
R_4792_4892 4792 4892 3.950437e+00
R_4892_4992 4892 4992 2.271180e+00
R_4992_5092 4992 5092 1.686159e+00
R_5092_5192 5092 5192 4.889653e+00
R_5192_5292 5192 5292 7.590527e-01
R_5292_5392 5292 5392 9.914541e+00
R_5392_5492 5392 5492 4.878587e+00
R_5492_5592 5492 5592 7.550662e+00
R_5592_5692 5592 5692 9.927058e+00
R_5692_5792 5692 5792 1.207124e+00
R_5792_5892 5792 5892 9.638042e+00
R_5892_5992 5892 5992 7.225579e+00
R_5992_6092 5992 6092 3.338869e+00
R_6092_6192 6092 6192 6.518535e+00
R_6192_6292 6192 6292 5.716167e+00
R_6292_6392 6292 6392 6.708664e+00
R_6392_6492 6392 6492 3.657703e+00
R_6492_6592 6492 6592 3.956848e+00
R_6592_6692 6592 6692 9.540516e+00
R_6692_6792 6692 6792 4.901689e+00
R_6792_6892 6792 6892 7.921316e+00
R_6892_6992 6892 6992 3.231801e+00
R_6992_7092 6992 7092 3.604475e+00
R_7092_7192 7092 7192 7.524150e-01
R_7192_7292 7192 7292 9.602388e+00
R_7292_7392 7292 7392 4.687869e-01
R_7392_7492 7392 7492 9.407142e+00
R_7492_7592 7492 7592 1.910800e+00
R_7592_7692 7592 7692 2.212120e+00
R_7692_7792 7692 7792 8.057901e+00
R_7792_7892 7792 7892 8.930628e+00
R_7892_7992 7892 7992 5.556084e+00
R_7992_8092 7992 8092 9.558945e+00
R_8092_8192 8092 8192 9.545689e+00
R_8192_8292 8192 8292 2.585595e+00
R_8292_8392 8292 8392 8.262225e+00
R_8392_8492 8392 8492 7.824640e+00
R_8492_8592 8492 8592 2.048206e+00
R_8592_8692 8592 8692 3.032641e+00
R_8692_8792 8692 8792 3.974122e+00
R_8792_8892 8792 8892 5.016229e+00
R_8892_8992 8892 8992 1.394471e+00
R_8992_9092 8992 9092 2.593016e+00
R_9092_9192 9092 9192 8.541168e+00
R_9192_9292 9192 9292 5.837330e+00
R_9292_9392 9292 9392 7.724362e+00
R_9392_9492 9392 9492 3.847320e+00
R_9492_9592 9492 9592 8.342268e+00
R_9592_9692 9592 9692 5.028306e+00
R_9692_9792 9692 9792 9.523882e+00
R_9792_9892 9792 9892 9.024093e+00
R_9892_9992 9892 9992 6.873708e+00
R_93_193 93 193 5.964648e+00
R_193_293 193 293 2.117023e+00
R_293_393 293 393 6.934024e+00
R_393_493 393 493 7.258905e-01
R_493_593 493 593 8.706420e+00
R_593_693 593 693 3.877859e+00
R_693_793 693 793 8.455972e+00
R_793_893 793 893 6.338303e+00
R_893_993 893 993 5.438392e+00
R_993_1093 993 1093 9.119105e+00
R_1093_1193 1093 1193 2.190106e+00
R_1193_1293 1193 1293 8.116442e+00
R_1293_1393 1293 1393 4.881523e+00
R_1393_1493 1393 1493 7.242340e+00
R_1493_1593 1493 1593 1.809297e+00
R_1593_1693 1593 1693 1.720953e+00
R_1693_1793 1693 1793 7.745622e-01
R_1793_1893 1793 1893 6.466786e+00
R_1893_1993 1893 1993 9.755791e+00
R_1993_2093 1993 2093 3.353885e+00
R_2093_2193 2093 2193 6.167323e+00
R_2193_2293 2193 2293 3.205102e+00
R_2293_2393 2293 2393 9.194631e+00
R_2393_2493 2393 2493 8.921617e+00
R_2493_2593 2493 2593 2.542701e+00
R_2593_2693 2593 2693 1.919286e+00
R_2693_2793 2693 2793 1.744179e+00
R_2793_2893 2793 2893 3.417920e+00
R_2893_2993 2893 2993 5.075072e-01
R_2993_3093 2993 3093 5.721830e+00
R_3093_3193 3093 3193 1.412851e+00
R_3193_3293 3193 3293 4.909739e+00
R_3293_3393 3293 3393 6.446190e-01
R_3393_3493 3393 3493 2.855403e+00
R_3493_3593 3493 3593 8.088422e+00
R_3593_3693 3593 3693 1.143042e+00
R_3693_3793 3693 3793 9.873651e+00
R_3793_3893 3793 3893 6.175387e+00
R_3893_3993 3893 3993 3.051007e+00
R_3993_4093 3993 4093 8.692594e+00
R_4093_4193 4093 4193 3.542453e-01
R_4193_4293 4193 4293 2.219057e+00
R_4293_4393 4293 4393 5.560497e+00
R_4393_4493 4393 4493 5.077118e+00
R_4493_4593 4493 4593 6.458059e+00
R_4593_4693 4593 4693 1.730102e+00
R_4693_4793 4693 4793 5.741191e+00
R_4793_4893 4793 4893 3.036232e+00
R_4893_4993 4893 4993 3.236422e-01
R_4993_5093 4993 5093 3.154761e+00
R_5093_5193 5093 5193 1.988323e+00
R_5193_5293 5193 5293 1.620666e-01
R_5293_5393 5293 5393 6.324417e+00
R_5393_5493 5393 5493 6.944319e+00
R_5493_5593 5493 5593 9.904370e+00
R_5593_5693 5593 5693 9.238671e+00
R_5693_5793 5693 5793 7.482812e+00
R_5793_5893 5793 5893 7.418635e+00
R_5893_5993 5893 5993 5.295708e+00
R_5993_6093 5993 6093 7.265489e+00
R_6093_6193 6093 6193 3.011279e-01
R_6193_6293 6193 6293 4.520810e+00
R_6293_6393 6293 6393 5.024927e+00
R_6393_6493 6393 6493 2.385713e+00
R_6493_6593 6493 6593 8.135828e+00
R_6593_6693 6593 6693 1.713550e+00
R_6693_6793 6693 6793 2.846544e+00
R_6793_6893 6793 6893 5.605026e+00
R_6893_6993 6893 6993 9.258017e+00
R_6993_7093 6993 7093 7.250733e+00
R_7093_7193 7093 7193 2.223073e+00
R_7193_7293 7193 7293 2.368126e-01
R_7293_7393 7293 7393 1.736567e+00
R_7393_7493 7393 7493 2.264375e+00
R_7493_7593 7493 7593 6.339274e+00
R_7593_7693 7593 7693 8.354992e-01
R_7693_7793 7693 7793 3.034381e+00
R_7793_7893 7793 7893 3.431253e+00
R_7893_7993 7893 7993 1.027619e+00
R_7993_8093 7993 8093 5.847059e+00
R_8093_8193 8093 8193 9.979276e+00
R_8193_8293 8193 8293 5.293928e+00
R_8293_8393 8293 8393 8.981603e+00
R_8393_8493 8393 8493 8.123390e+00
R_8493_8593 8493 8593 6.099033e-01
R_8593_8693 8593 8693 1.941775e-01
R_8693_8793 8693 8793 6.732884e+00
R_8793_8893 8793 8893 9.042710e+00
R_8893_8993 8893 8993 9.454581e+00
R_8993_9093 8993 9093 9.005694e+00
R_9093_9193 9093 9193 4.484817e+00
R_9193_9293 9193 9293 7.818939e+00
R_9293_9393 9293 9393 6.410593e-01
R_9393_9493 9393 9493 4.433581e+00
R_9493_9593 9493 9593 1.293969e+00
R_9593_9693 9593 9693 2.064647e+00
R_9693_9793 9693 9793 3.301692e+00
R_9793_9893 9793 9893 9.249107e+00
R_9893_9993 9893 9993 7.487429e+00
R_94_194 94 194 5.639758e+00
R_194_294 194 294 5.572265e+00
R_294_394 294 394 3.874125e+00
R_394_494 394 494 5.590372e+00
R_494_594 494 594 6.433953e+00
R_594_694 594 694 4.315253e+00
R_694_794 694 794 7.370276e+00
R_794_894 794 894 6.695646e-01
R_894_994 894 994 4.814619e+00
R_994_1094 994 1094 3.381698e+00
R_1094_1194 1094 1194 6.969075e+00
R_1194_1294 1194 1294 7.437858e+00
R_1294_1394 1294 1394 8.610531e+00
R_1394_1494 1394 1494 3.822174e+00
R_1494_1594 1494 1594 5.031180e-02
R_1594_1694 1594 1694 6.373350e+00
R_1694_1794 1694 1794 5.180474e+00
R_1794_1894 1794 1894 5.202335e+00
R_1894_1994 1894 1994 3.231654e+00
R_1994_2094 1994 2094 5.633520e+00
R_2094_2194 2094 2194 3.589197e+00
R_2194_2294 2194 2294 7.852253e+00
R_2294_2394 2294 2394 6.476407e+00
R_2394_2494 2394 2494 1.044530e+00
R_2494_2594 2494 2594 8.923184e+00
R_2594_2694 2594 2694 2.753901e+00
R_2694_2794 2694 2794 6.129620e+00
R_2794_2894 2794 2894 3.996605e+00
R_2894_2994 2894 2994 7.335112e+00
R_2994_3094 2994 3094 7.465418e+00
R_3094_3194 3094 3194 3.284788e+00
R_3194_3294 3194 3294 5.055362e+00
R_3294_3394 3294 3394 3.448737e+00
R_3394_3494 3394 3494 7.235761e+00
R_3494_3594 3494 3594 3.716569e+00
R_3594_3694 3594 3694 7.178380e+00
R_3694_3794 3694 3794 6.087835e+00
R_3794_3894 3794 3894 7.306143e+00
R_3894_3994 3894 3994 4.836141e-01
R_3994_4094 3994 4094 1.517189e+00
R_4094_4194 4094 4194 1.929191e+00
R_4194_4294 4194 4294 7.421886e+00
R_4294_4394 4294 4394 6.143007e+00
R_4394_4494 4394 4494 1.831224e+00
R_4494_4594 4494 4594 2.738460e+00
R_4594_4694 4594 4694 2.770735e+00
R_4694_4794 4694 4794 4.289615e+00
R_4794_4894 4794 4894 4.982128e+00
R_4894_4994 4894 4994 7.361447e+00
R_4994_5094 4994 5094 5.012568e+00
R_5094_5194 5094 5194 2.703108e-01
R_5194_5294 5194 5294 7.117220e+00
R_5294_5394 5294 5394 4.857312e+00
R_5394_5494 5394 5494 5.122428e-01
R_5494_5594 5494 5594 8.315251e+00
R_5594_5694 5594 5694 2.179268e+00
R_5694_5794 5694 5794 7.349773e+00
R_5794_5894 5794 5894 5.823115e+00
R_5894_5994 5894 5994 6.085976e+00
R_5994_6094 5994 6094 3.376206e+00
R_6094_6194 6094 6194 2.354905e+00
R_6194_6294 6194 6294 5.956816e-01
R_6294_6394 6294 6394 8.400380e+00
R_6394_6494 6394 6494 9.797979e+00
R_6494_6594 6494 6594 8.045798e+00
R_6594_6694 6594 6694 8.722378e-02
R_6694_6794 6694 6794 4.745563e+00
R_6794_6894 6794 6894 7.625539e+00
R_6894_6994 6894 6994 2.221301e+00
R_6994_7094 6994 7094 7.657366e+00
R_7094_7194 7094 7194 4.270862e+00
R_7194_7294 7194 7294 6.095574e+00
R_7294_7394 7294 7394 5.350228e+00
R_7394_7494 7394 7494 3.557183e+00
R_7494_7594 7494 7594 9.549092e+00
R_7594_7694 7594 7694 9.358300e+00
R_7694_7794 7694 7794 2.269025e+00
R_7794_7894 7794 7894 4.238480e+00
R_7894_7994 7894 7994 1.440881e-01
R_7994_8094 7994 8094 5.820158e+00
R_8094_8194 8094 8194 2.846508e-01
R_8194_8294 8194 8294 4.158505e-01
R_8294_8394 8294 8394 4.289637e+00
R_8394_8494 8394 8494 6.608378e+00
R_8494_8594 8494 8594 5.564970e+00
R_8594_8694 8594 8694 4.112298e+00
R_8694_8794 8694 8794 4.654002e+00
R_8794_8894 8794 8894 1.892510e+00
R_8894_8994 8894 8994 5.067097e+00
R_8994_9094 8994 9094 2.380637e+00
R_9094_9194 9094 9194 4.081068e+00
R_9194_9294 9194 9294 4.981310e+00
R_9294_9394 9294 9394 3.043316e+00
R_9394_9494 9394 9494 6.015618e+00
R_9494_9594 9494 9594 5.691659e+00
R_9594_9694 9594 9694 9.151662e-01
R_9694_9794 9694 9794 1.852786e+00
R_9794_9894 9794 9894 6.968716e-01
R_9894_9994 9894 9994 5.089111e+00
R_95_195 95 195 5.410583e+00
R_195_295 195 295 7.405824e+00
R_295_395 295 395 5.240183e+00
R_395_495 395 495 6.813401e-01
R_495_595 495 595 1.489705e+00
R_595_695 595 695 7.832519e+00
R_695_795 695 795 9.569673e+00
R_795_895 795 895 3.896997e-02
R_895_995 895 995 8.367918e+00
R_995_1095 995 1095 7.520265e+00
R_1095_1195 1095 1195 8.633313e+00
R_1195_1295 1195 1295 1.750869e+00
R_1295_1395 1295 1395 2.651097e+00
R_1395_1495 1395 1495 9.212358e+00
R_1495_1595 1495 1595 4.913780e+00
R_1595_1695 1595 1695 3.172586e-01
R_1695_1795 1695 1795 4.430239e+00
R_1795_1895 1795 1895 3.020954e+00
R_1895_1995 1895 1995 3.136633e+00
R_1995_2095 1995 2095 9.603898e+00
R_2095_2195 2095 2195 6.269731e+00
R_2195_2295 2195 2295 2.773614e+00
R_2295_2395 2295 2395 1.775481e+00
R_2395_2495 2395 2495 9.485407e+00
R_2495_2595 2495 2595 1.110876e+00
R_2595_2695 2595 2695 2.544671e+00
R_2695_2795 2695 2795 8.349370e+00
R_2795_2895 2795 2895 3.186616e+00
R_2895_2995 2895 2995 9.911961e+00
R_2995_3095 2995 3095 8.689155e+00
R_3095_3195 3095 3195 3.215162e+00
R_3195_3295 3195 3295 9.491475e+00
R_3295_3395 3295 3395 8.514940e-01
R_3395_3495 3395 3495 3.153794e+00
R_3495_3595 3495 3595 7.201506e+00
R_3595_3695 3595 3695 9.176842e+00
R_3695_3795 3695 3795 8.895296e+00
R_3795_3895 3795 3895 4.079511e+00
R_3895_3995 3895 3995 3.393184e+00
R_3995_4095 3995 4095 4.541685e+00
R_4095_4195 4095 4195 2.616647e+00
R_4195_4295 4195 4295 1.424397e+00
R_4295_4395 4295 4395 4.876650e+00
R_4395_4495 4395 4495 5.970347e+00
R_4495_4595 4495 4595 9.005054e+00
R_4595_4695 4595 4695 6.592414e+00
R_4695_4795 4695 4795 5.559575e+00
R_4795_4895 4795 4895 2.293898e+00
R_4895_4995 4895 4995 7.507651e+00
R_4995_5095 4995 5095 1.332864e+00
R_5095_5195 5095 5195 7.527188e+00
R_5195_5295 5195 5295 6.196115e+00
R_5295_5395 5295 5395 1.739244e+00
R_5395_5495 5395 5495 8.113694e-01
R_5495_5595 5495 5595 3.741152e+00
R_5595_5695 5595 5695 3.516889e+00
R_5695_5795 5695 5795 4.198296e+00
R_5795_5895 5795 5895 4.323377e+00
R_5895_5995 5895 5995 7.629378e+00
R_5995_6095 5995 6095 4.778709e-01
R_6095_6195 6095 6195 7.729032e+00
R_6195_6295 6195 6295 6.805555e-01
R_6295_6395 6295 6395 4.908177e+00
R_6395_6495 6395 6495 8.290594e+00
R_6495_6595 6495 6595 9.982808e+00
R_6595_6695 6595 6695 5.718127e+00
R_6695_6795 6695 6795 6.358930e+00
R_6795_6895 6795 6895 2.735041e+00
R_6895_6995 6895 6995 3.249440e+00
R_6995_7095 6995 7095 8.707065e+00
R_7095_7195 7095 7195 9.970707e+00
R_7195_7295 7195 7295 6.988455e-01
R_7295_7395 7295 7395 4.819997e+00
R_7395_7495 7395 7495 3.214610e+00
R_7495_7595 7495 7595 7.493698e+00
R_7595_7695 7595 7695 4.341448e+00
R_7695_7795 7695 7795 8.663074e+00
R_7795_7895 7795 7895 6.982565e+00
R_7895_7995 7895 7995 7.779462e+00
R_7995_8095 7995 8095 4.157081e+00
R_8095_8195 8095 8195 7.176507e+00
R_8195_8295 8195 8295 2.589467e+00
R_8295_8395 8295 8395 8.143319e+00
R_8395_8495 8395 8495 2.269333e+00
R_8495_8595 8495 8595 1.904955e+00
R_8595_8695 8595 8695 9.439290e+00
R_8695_8795 8695 8795 1.962353e+00
R_8795_8895 8795 8895 7.615616e+00
R_8895_8995 8895 8995 1.642273e+00
R_8995_9095 8995 9095 3.889283e+00
R_9095_9195 9095 9195 1.831426e+00
R_9195_9295 9195 9295 4.800088e+00
R_9295_9395 9295 9395 2.000974e+00
R_9395_9495 9395 9495 9.495778e+00
R_9495_9595 9495 9595 6.325272e-01
R_9595_9695 9595 9695 4.530139e+00
R_9695_9795 9695 9795 6.363804e+00
R_9795_9895 9795 9895 4.412957e+00
R_9895_9995 9895 9995 4.275461e-01
R_96_196 96 196 2.355887e+00
R_196_296 196 296 3.945340e+00
R_296_396 296 396 5.008393e+00
R_396_496 396 496 2.141522e+00
R_496_596 496 596 8.032682e+00
R_596_696 596 696 9.602854e+00
R_696_796 696 796 7.425682e-01
R_796_896 796 896 5.674112e+00
R_896_996 896 996 9.539615e+00
R_996_1096 996 1096 2.272662e+00
R_1096_1196 1096 1196 1.352191e+00
R_1196_1296 1196 1296 1.983504e+00
R_1296_1396 1296 1396 7.748784e+00
R_1396_1496 1396 1496 3.494929e+00
R_1496_1596 1496 1596 6.255575e+00
R_1596_1696 1596 1696 4.987476e-01
R_1696_1796 1696 1796 9.053669e+00
R_1796_1896 1796 1896 5.408030e-01
R_1896_1996 1896 1996 9.242124e+00
R_1996_2096 1996 2096 9.909548e+00
R_2096_2196 2096 2196 8.274073e+00
R_2196_2296 2196 2296 9.700808e+00
R_2296_2396 2296 2396 1.264314e+00
R_2396_2496 2396 2496 3.088626e+00
R_2496_2596 2496 2596 8.080902e+00
R_2596_2696 2596 2696 1.580074e+00
R_2696_2796 2696 2796 1.504760e+00
R_2796_2896 2796 2896 6.082593e+00
R_2896_2996 2896 2996 8.518352e+00
R_2996_3096 2996 3096 1.747312e+00
R_3096_3196 3096 3196 4.396960e+00
R_3196_3296 3196 3296 9.947374e+00
R_3296_3396 3296 3396 6.754229e+00
R_3396_3496 3396 3496 1.632031e+00
R_3496_3596 3496 3596 6.613954e+00
R_3596_3696 3596 3696 9.004143e+00
R_3696_3796 3696 3796 2.161333e+00
R_3796_3896 3796 3896 6.487478e+00
R_3896_3996 3896 3996 3.431907e+00
R_3996_4096 3996 4096 2.998269e+00
R_4096_4196 4096 4196 4.988012e+00
R_4196_4296 4196 4296 6.101060e+00
R_4296_4396 4296 4396 3.317109e+00
R_4396_4496 4396 4496 3.328713e+00
R_4496_4596 4496 4596 2.252435e+00
R_4596_4696 4596 4696 9.169728e+00
R_4696_4796 4696 4796 1.107047e+00
R_4796_4896 4796 4896 6.283656e+00
R_4896_4996 4896 4996 9.577787e+00
R_4996_5096 4996 5096 3.010888e-01
R_5096_5196 5096 5196 6.169336e+00
R_5196_5296 5196 5296 8.821725e+00
R_5296_5396 5296 5396 8.607119e+00
R_5396_5496 5396 5496 7.695442e+00
R_5496_5596 5496 5596 3.391081e+00
R_5596_5696 5596 5696 5.783455e+00
R_5696_5796 5696 5796 5.576890e+00
R_5796_5896 5796 5896 4.259406e+00
R_5896_5996 5896 5996 6.517915e+00
R_5996_6096 5996 6096 3.428720e+00
R_6096_6196 6096 6196 3.478305e+00
R_6196_6296 6196 6296 9.367980e+00
R_6296_6396 6296 6396 3.494437e+00
R_6396_6496 6396 6496 8.995487e+00
R_6496_6596 6496 6596 2.897412e+00
R_6596_6696 6596 6696 9.228000e+00
R_6696_6796 6696 6796 8.911794e+00
R_6796_6896 6796 6896 8.571874e+00
R_6896_6996 6896 6996 9.311853e+00
R_6996_7096 6996 7096 6.065692e+00
R_7096_7196 7096 7196 6.844476e+00
R_7196_7296 7196 7296 1.699607e+00
R_7296_7396 7296 7396 6.984054e+00
R_7396_7496 7396 7496 2.499908e+00
R_7496_7596 7496 7596 8.798647e+00
R_7596_7696 7596 7696 8.182215e+00
R_7696_7796 7696 7796 2.898869e-01
R_7796_7896 7796 7896 4.450510e+00
R_7896_7996 7896 7996 5.683677e+00
R_7996_8096 7996 8096 6.500908e+00
R_8096_8196 8096 8196 7.338243e+00
R_8196_8296 8196 8296 2.474171e+00
R_8296_8396 8296 8396 4.621273e+00
R_8396_8496 8396 8496 6.394004e+00
R_8496_8596 8496 8596 5.298822e+00
R_8596_8696 8596 8696 9.262191e+00
R_8696_8796 8696 8796 4.529021e+00
R_8796_8896 8796 8896 2.117247e+00
R_8896_8996 8896 8996 7.424566e-02
R_8996_9096 8996 9096 5.546084e+00
R_9096_9196 9096 9196 8.014061e+00
R_9196_9296 9196 9296 2.778318e+00
R_9296_9396 9296 9396 2.275544e+00
R_9396_9496 9396 9496 2.393969e+00
R_9496_9596 9496 9596 2.885983e+00
R_9596_9696 9596 9696 9.177468e-01
R_9696_9796 9696 9796 3.779475e+00
R_9796_9896 9796 9896 5.493218e+00
R_9896_9996 9896 9996 5.615222e-01
R_97_197 97 197 9.380462e+00
R_197_297 197 297 4.085950e+00
R_297_397 297 397 6.735971e+00
R_397_497 397 497 5.578683e+00
R_497_597 497 597 9.538292e+00
R_597_697 597 697 5.201847e+00
R_697_797 697 797 4.692813e+00
R_797_897 797 897 1.236920e+00
R_897_997 897 997 8.367496e-01
R_997_1097 997 1097 5.028540e+00
R_1097_1197 1097 1197 4.801974e+00
R_1197_1297 1197 1297 9.003373e+00
R_1297_1397 1297 1397 7.143267e+00
R_1397_1497 1397 1497 2.678313e+00
R_1497_1597 1497 1597 5.525400e+00
R_1597_1697 1597 1697 2.698800e+00
R_1697_1797 1697 1797 9.076298e+00
R_1797_1897 1797 1897 4.508140e+00
R_1897_1997 1897 1997 8.865690e+00
R_1997_2097 1997 2097 2.706923e-01
R_2097_2197 2097 2197 6.324721e+00
R_2197_2297 2197 2297 3.801504e+00
R_2297_2397 2297 2397 9.263783e+00
R_2397_2497 2397 2497 1.223590e+00
R_2497_2597 2497 2597 5.025553e+00
R_2597_2697 2597 2697 3.947985e-01
R_2697_2797 2697 2797 4.205358e+00
R_2797_2897 2797 2897 4.696200e+00
R_2897_2997 2897 2997 2.459955e-01
R_2997_3097 2997 3097 5.102496e+00
R_3097_3197 3097 3197 5.701816e+00
R_3197_3297 3197 3297 5.333790e+00
R_3297_3397 3297 3397 9.307998e+00
R_3397_3497 3397 3497 8.701263e+00
R_3497_3597 3497 3597 6.447921e-01
R_3597_3697 3597 3697 7.877628e+00
R_3697_3797 3697 3797 8.004729e+00
R_3797_3897 3797 3897 7.337370e+00
R_3897_3997 3897 3997 6.327812e+00
R_3997_4097 3997 4097 2.142242e+00
R_4097_4197 4097 4197 4.942589e-02
R_4197_4297 4197 4297 1.105695e+00
R_4297_4397 4297 4397 3.975109e+00
R_4397_4497 4397 4497 7.077967e+00
R_4497_4597 4497 4597 8.517182e+00
R_4597_4697 4597 4697 2.989219e+00
R_4697_4797 4697 4797 3.501820e-01
R_4797_4897 4797 4897 7.048857e+00
R_4897_4997 4897 4997 7.349561e+00
R_4997_5097 4997 5097 3.132215e+00
R_5097_5197 5097 5197 3.115116e+00
R_5197_5297 5197 5297 3.417733e+00
R_5297_5397 5297 5397 8.253878e+00
R_5397_5497 5397 5497 9.471797e+00
R_5497_5597 5497 5597 8.461679e+00
R_5597_5697 5597 5697 1.818682e+00
R_5697_5797 5697 5797 7.717605e+00
R_5797_5897 5797 5897 6.268353e+00
R_5897_5997 5897 5997 7.010566e+00
R_5997_6097 5997 6097 3.392610e+00
R_6097_6197 6097 6197 8.552619e+00
R_6197_6297 6197 6297 7.492260e+00
R_6297_6397 6297 6397 6.165233e+00
R_6397_6497 6397 6497 5.372609e-01
R_6497_6597 6497 6597 8.769386e-01
R_6597_6697 6597 6697 9.316145e+00
R_6697_6797 6697 6797 8.870212e+00
R_6797_6897 6797 6897 3.324243e+00
R_6897_6997 6897 6997 7.284303e+00
R_6997_7097 6997 7097 4.798691e+00
R_7097_7197 7097 7197 8.490260e+00
R_7197_7297 7197 7297 8.106327e+00
R_7297_7397 7297 7397 8.058807e+00
R_7397_7497 7397 7497 9.634673e+00
R_7497_7597 7497 7597 2.084703e+00
R_7597_7697 7597 7697 6.798171e+00
R_7697_7797 7697 7797 7.918396e+00
R_7797_7897 7797 7897 1.333178e+00
R_7897_7997 7897 7997 2.187545e+00
R_7997_8097 7997 8097 3.025402e+00
R_8097_8197 8097 8197 1.636643e+00
R_8197_8297 8197 8297 9.224316e+00
R_8297_8397 8297 8397 4.070185e+00
R_8397_8497 8397 8497 2.913446e+00
R_8497_8597 8497 8597 2.241195e+00
R_8597_8697 8597 8697 3.959544e+00
R_8697_8797 8697 8797 7.091997e+00
R_8797_8897 8797 8897 9.285960e+00
R_8897_8997 8897 8997 3.751261e+00
R_8997_9097 8997 9097 2.341194e+00
R_9097_9197 9097 9197 7.901929e+00
R_9197_9297 9197 9297 8.626545e+00
R_9297_9397 9297 9397 3.839458e+00
R_9397_9497 9397 9497 2.675318e+00
R_9497_9597 9497 9597 3.959833e+00
R_9597_9697 9597 9697 1.393812e+00
R_9697_9797 9697 9797 7.916067e+00
R_9797_9897 9797 9897 4.044102e+00
R_9897_9997 9897 9997 1.495788e-01
R_98_198 98 198 6.940790e+00
R_198_298 198 298 1.069121e+00
R_298_398 298 398 6.356356e+00
R_398_498 398 498 5.607530e+00
R_498_598 498 598 1.794761e-01
R_598_698 598 698 8.427513e+00
R_698_798 698 798 2.470105e+00
R_798_898 798 898 2.826367e+00
R_898_998 898 998 3.257144e+00
R_998_1098 998 1098 7.236499e+00
R_1098_1198 1098 1198 1.527646e+00
R_1198_1298 1198 1298 6.961581e+00
R_1298_1398 1298 1398 2.183715e+00
R_1398_1498 1398 1498 1.597183e+00
R_1498_1598 1498 1598 4.295533e+00
R_1598_1698 1598 1698 7.604791e-01
R_1698_1798 1698 1798 6.216252e+00
R_1798_1898 1798 1898 2.362122e+00
R_1898_1998 1898 1998 6.771273e+00
R_1998_2098 1998 2098 8.512479e+00
R_2098_2198 2098 2198 3.464689e+00
R_2198_2298 2198 2298 2.291738e+00
R_2298_2398 2298 2398 3.139345e+00
R_2398_2498 2398 2498 8.032781e-01
R_2498_2598 2498 2598 8.180499e+00
R_2598_2698 2598 2698 6.688624e+00
R_2698_2798 2698 2798 8.679412e-01
R_2798_2898 2798 2898 8.917899e+00
R_2898_2998 2898 2998 8.893260e+00
R_2998_3098 2998 3098 8.401245e-01
R_3098_3198 3098 3198 9.272457e+00
R_3198_3298 3198 3298 9.463222e+00
R_3298_3398 3298 3398 7.699079e-01
R_3398_3498 3398 3498 4.111469e-01
R_3498_3598 3498 3598 3.802955e+00
R_3598_3698 3598 3698 4.369991e+00
R_3698_3798 3698 3798 5.755619e+00
R_3798_3898 3798 3898 8.211842e+00
R_3898_3998 3898 3998 2.699071e-02
R_3998_4098 3998 4098 5.743308e+00
R_4098_4198 4098 4198 2.778754e+00
R_4198_4298 4198 4298 6.712783e+00
R_4298_4398 4298 4398 1.646699e+00
R_4398_4498 4398 4498 4.443524e+00
R_4498_4598 4498 4598 8.103908e+00
R_4598_4698 4598 4698 6.069924e+00
R_4698_4798 4698 4798 1.368719e+00
R_4798_4898 4798 4898 1.032056e+00
R_4898_4998 4898 4998 3.295814e+00
R_4998_5098 4998 5098 2.171669e+00
R_5098_5198 5098 5198 8.732476e+00
R_5198_5298 5198 5298 8.591238e+00
R_5298_5398 5298 5398 8.064193e+00
R_5398_5498 5398 5498 9.750021e+00
R_5498_5598 5498 5598 5.959736e+00
R_5598_5698 5598 5698 7.388383e+00
R_5698_5798 5698 5798 1.063485e+00
R_5798_5898 5798 5898 8.611346e+00
R_5898_5998 5898 5998 4.573957e+00
R_5998_6098 5998 6098 2.577195e-01
R_6098_6198 6098 6198 8.036209e+00
R_6198_6298 6198 6298 9.213992e+00
R_6298_6398 6298 6398 3.650081e+00
R_6398_6498 6398 6498 6.896421e+00
R_6498_6598 6498 6598 6.619368e+00
R_6598_6698 6598 6698 1.495445e+00
R_6698_6798 6698 6798 3.769364e+00
R_6798_6898 6798 6898 8.817466e+00
R_6898_6998 6898 6998 3.799996e+00
R_6998_7098 6998 7098 6.379793e+00
R_7098_7198 7098 7198 9.202941e+00
R_7198_7298 7198 7298 1.603946e+00
R_7298_7398 7298 7398 2.414192e+00
R_7398_7498 7398 7498 5.866441e-01
R_7498_7598 7498 7598 2.430112e+00
R_7598_7698 7598 7698 2.306848e-01
R_7698_7798 7698 7798 1.565634e+00
R_7798_7898 7798 7898 2.251937e-01
R_7898_7998 7898 7998 9.880721e+00
R_7998_8098 7998 8098 5.006520e+00
R_8098_8198 8098 8198 8.672131e+00
R_8198_8298 8198 8298 8.231149e+00
R_8298_8398 8298 8398 2.198143e+00
R_8398_8498 8398 8498 7.372503e+00
R_8498_8598 8498 8598 1.001582e-01
R_8598_8698 8598 8698 2.896658e+00
R_8698_8798 8698 8798 8.737868e+00
R_8798_8898 8798 8898 5.394352e+00
R_8898_8998 8898 8998 3.749596e+00
R_8998_9098 8998 9098 8.499590e-01
R_9098_9198 9098 9198 4.223491e+00
R_9198_9298 9198 9298 7.462918e+00
R_9298_9398 9298 9398 4.774395e+00
R_9398_9498 9398 9498 2.447944e-01
R_9498_9598 9498 9598 9.200272e+00
R_9598_9698 9598 9698 8.299781e+00
R_9698_9798 9698 9798 1.570320e+00
R_9798_9898 9798 9898 7.542514e+00
R_9898_9998 9898 9998 2.861976e+00
R_99_199 99 199 1.357968e+00
R_199_299 199 299 2.141001e+00
R_299_399 299 399 5.080398e+00
R_399_499 399 499 3.874970e+00
R_499_599 499 599 4.044346e+00
R_599_699 599 699 1.096897e+00
R_699_799 699 799 1.600573e+00
R_799_899 799 899 8.747340e+00
R_899_999 899 999 8.849184e-01
R_999_1099 999 1099 6.071101e+00
R_1099_1199 1099 1199 7.212996e+00
R_1199_1299 1199 1299 1.906205e+00
R_1299_1399 1299 1399 5.762612e+00
R_1399_1499 1399 1499 6.233412e+00
R_1499_1599 1499 1599 7.650421e+00
R_1599_1699 1599 1699 5.355614e+00
R_1699_1799 1699 1799 8.150974e+00
R_1799_1899 1799 1899 6.420079e+00
R_1899_1999 1899 1999 6.440356e+00
R_1999_2099 1999 2099 3.558456e-01
R_2099_2199 2099 2199 1.288120e+00
R_2199_2299 2199 2299 4.830837e+00
R_2299_2399 2299 2399 4.543377e-01
R_2399_2499 2399 2499 4.198821e+00
R_2499_2599 2499 2599 4.452237e+00
R_2599_2699 2599 2699 6.715294e+00
R_2699_2799 2699 2799 6.878889e+00
R_2799_2899 2799 2899 8.229693e+00
R_2899_2999 2899 2999 1.241765e+00
R_2999_3099 2999 3099 8.455574e+00
R_3099_3199 3099 3199 9.760859e+00
R_3199_3299 3199 3299 8.812401e+00
R_3299_3399 3299 3399 9.537353e+00
R_3399_3499 3399 3499 3.395464e+00
R_3499_3599 3499 3599 9.912973e+00
R_3599_3699 3599 3699 1.613356e+00
R_3699_3799 3699 3799 9.255687e+00
R_3799_3899 3799 3899 5.000847e+00
R_3899_3999 3899 3999 1.678904e+00
R_3999_4099 3999 4099 6.135563e+00
R_4099_4199 4099 4199 6.279859e-01
R_4199_4299 4199 4299 4.381451e+00
R_4299_4399 4299 4399 9.969092e+00
R_4399_4499 4399 4499 8.944259e+00
R_4499_4599 4499 4599 8.582440e+00
R_4599_4699 4599 4699 3.834436e+00
R_4699_4799 4699 4799 4.416718e+00
R_4799_4899 4799 4899 5.274101e+00
R_4899_4999 4899 4999 6.205019e+00
R_4999_5099 4999 5099 4.973301e+00
R_5099_5199 5099 5199 7.207354e+00
R_5199_5299 5199 5299 7.745722e+00
R_5299_5399 5299 5399 1.955873e+00
R_5399_5499 5399 5499 2.993766e-01
R_5499_5599 5499 5599 2.179106e-01
R_5599_5699 5599 5699 4.576009e+00
R_5699_5799 5699 5799 1.535362e+00
R_5799_5899 5799 5899 7.206874e+00
R_5899_5999 5899 5999 8.087054e+00
R_5999_6099 5999 6099 8.150778e+00
R_6099_6199 6099 6199 2.444304e+00
R_6199_6299 6199 6299 6.444263e+00
R_6299_6399 6299 6399 7.689174e+00
R_6399_6499 6399 6499 7.903491e+00
R_6499_6599 6499 6599 8.249525e+00
R_6599_6699 6599 6699 5.249319e+00
R_6699_6799 6699 6799 4.600618e+00
R_6799_6899 6799 6899 8.377911e+00
R_6899_6999 6899 6999 9.534255e+00
R_6999_7099 6999 7099 9.867045e+00
R_7099_7199 7099 7199 4.921063e+00
R_7199_7299 7199 7299 3.985450e+00
R_7299_7399 7299 7399 1.542377e+00
R_7399_7499 7399 7499 1.407585e+00
R_7499_7599 7499 7599 8.185089e+00
R_7599_7699 7599 7699 1.810750e+00
R_7699_7799 7699 7799 1.046764e+00
R_7799_7899 7799 7899 4.707285e+00
R_7899_7999 7899 7999 8.139791e+00
R_7999_8099 7999 8099 3.236969e+00
R_8099_8199 8099 8199 3.167479e+00
R_8199_8299 8199 8299 7.852808e+00
R_8299_8399 8299 8399 9.863134e+00
R_8399_8499 8399 8499 9.909280e+00
R_8499_8599 8499 8599 7.662339e+00
R_8599_8699 8599 8699 8.297399e+00
R_8699_8799 8699 8799 7.012349e+00
R_8799_8899 8799 8899 3.048395e+00
R_8899_8999 8899 8999 3.076249e-01
R_8999_9099 8999 9099 4.867710e+00
R_9099_9199 9099 9199 4.828699e-01
R_9199_9299 9199 9299 6.825140e+00
R_9299_9399 9299 9399 6.589597e+00
R_9399_9499 9399 9499 4.253827e+00
R_9499_9599 9499 9599 7.403858e+00
R_9599_9699 9599 9699 8.333669e+00
R_9699_9799 9699 9799 2.532010e+00
R_9799_9899 9799 9899 5.661771e+00
R_9899_9999 9899 9999 9.652367e+00
R_100_200 100 200 3.163015e+00
R_200_300 200 300 1.982285e-01
R_300_400 300 400 6.489960e+00
R_400_500 400 500 3.222019e+00
R_500_600 500 600 3.645669e+00
R_600_700 600 700 8.231164e+00
R_700_800 700 800 4.556073e+00
R_800_900 800 900 9.760655e+00
R_900_1000 900 1000 5.761341e+00
R_1000_1100 1000 1100 5.453931e+00
R_1100_1200 1100 1200 5.492370e+00
R_1200_1300 1200 1300 7.380133e+00
R_1300_1400 1300 1400 7.256361e+00
R_1400_1500 1400 1500 2.087144e+00
R_1500_1600 1500 1600 3.272654e+00
R_1600_1700 1600 1700 6.400344e+00
R_1700_1800 1700 1800 2.365115e+00
R_1800_1900 1800 1900 4.923644e+00
R_1900_2000 1900 2000 8.134324e+00
R_2000_2100 2000 2100 9.454776e+00
R_2100_2200 2100 2200 4.987912e+00
R_2200_2300 2200 2300 7.938111e+00
R_2300_2400 2300 2400 4.725739e+00
R_2400_2500 2400 2500 4.160019e+00
R_2500_2600 2500 2600 6.528706e+00
R_2600_2700 2600 2700 2.602366e+00
R_2700_2800 2700 2800 4.495689e+00
R_2800_2900 2800 2900 9.723163e+00
R_2900_3000 2900 3000 5.539939e+00
R_3000_3100 3000 3100 9.125711e+00
R_3100_3200 3100 3200 7.148878e+00
R_3200_3300 3200 3300 4.199095e+00
R_3300_3400 3300 3400 5.509735e+00
R_3400_3500 3400 3500 6.560048e+00
R_3500_3600 3500 3600 4.111246e+00
R_3600_3700 3600 3700 6.640064e-01
R_3700_3800 3700 3800 9.842187e+00
R_3800_3900 3800 3900 8.112176e+00
R_3900_4000 3900 4000 1.296878e+00
R_4000_4100 4000 4100 3.165197e+00
R_4100_4200 4100 4200 1.034004e+00
R_4200_4300 4200 4300 9.067220e+00
R_4300_4400 4300 4400 4.203109e+00
R_4400_4500 4400 4500 5.216712e+00
R_4500_4600 4500 4600 9.080750e+00
R_4600_4700 4600 4700 9.771060e-01
R_4700_4800 4700 4800 8.322647e+00
R_4800_4900 4800 4900 8.679476e+00
R_4900_5000 4900 5000 8.512354e+00
R_5000_5100 5000 5100 2.554307e+00
R_5100_5200 5100 5200 2.862103e+00
R_5200_5300 5200 5300 5.433595e+00
R_5300_5400 5300 5400 2.694937e+00
R_5400_5500 5400 5500 7.508801e-01
R_5500_5600 5500 5600 4.440897e+00
R_5600_5700 5600 5700 7.669450e+00
R_5700_5800 5700 5800 6.526547e-01
R_5800_5900 5800 5900 3.272511e-01
R_5900_6000 5900 6000 3.343281e-01
R_6000_6100 6000 6100 5.995847e+00
R_6100_6200 6100 6200 8.361512e+00
R_6200_6300 6200 6300 8.534659e-01
R_6300_6400 6300 6400 6.548703e+00
R_6400_6500 6400 6500 4.687149e+00
R_6500_6600 6500 6600 2.000407e-01
R_6600_6700 6600 6700 5.877922e-01
R_6700_6800 6700 6800 1.709207e-01
R_6800_6900 6800 6900 1.379424e+00
R_6900_7000 6900 7000 3.653907e+00
R_7000_7100 7000 7100 5.948713e+00
R_7100_7200 7100 7200 9.023159e+00
R_7200_7300 7200 7300 8.481793e+00
R_7300_7400 7300 7400 7.719489e+00
R_7400_7500 7400 7500 5.107645e+00
R_7500_7600 7500 7600 1.724995e+00
R_7600_7700 7600 7700 2.758725e+00
R_7700_7800 7700 7800 6.855417e+00
R_7800_7900 7800 7900 3.971335e+00
R_7900_8000 7900 8000 3.768430e+00
R_8000_8100 8000 8100 7.084826e+00
R_8100_8200 8100 8200 7.912680e+00
R_8200_8300 8200 8300 8.019536e+00
R_8300_8400 8300 8400 3.695909e+00
R_8400_8500 8400 8500 2.125771e+00
R_8500_8600 8500 8600 7.449424e+00
R_8600_8700 8600 8700 2.383266e+00
R_8700_8800 8700 8800 6.624392e+00
R_8800_8900 8800 8900 2.567130e+00
R_8900_9000 8900 9000 3.657403e+00
R_9000_9100 9000 9100 3.610719e+00
R_9100_9200 9100 9200 1.282921e+00
R_9200_9300 9200 9300 4.438973e+00
R_9300_9400 9300 9400 6.564204e+00
R_9400_9500 9400 9500 1.043277e+00
R_9500_9600 9500 9600 2.129319e+00
R_9600_9700 9600 9700 1.256236e+00
R_9700_9800 9700 9800 5.765359e+00
R_9800_9900 9800 9900 6.007788e+00
R_9900_10000 9900 10000 1.076273e+00
V_100_0 100 0 DC 1 AC 1
I_0_10000 0 10000 DC 0.100000 AC 0.100000
.DC V_100_0 1 10 1
.PRINT DC V(51) V(9951)
.ENDS
